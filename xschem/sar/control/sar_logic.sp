* SPICE netlist generated by Yosys 0.8 (git sha1 5706e90)

.SUBCKT sar_logic clk rstn en comp cal valid result.0 result.1 result.2 result.3 result.4 result.5 result.6 result.7 sample ctlp.0 ctlp.1 ctlp.2 ctlp.3 ctlp.4 ctlp.5 ctlp.6 ctlp.7 ctln.0 ctln.1 ctln.2 ctln.3 ctln.4 ctln.5 ctln.6 ctln.7 trim.0 trim.1 trim.2 trim.3 trim.4 trimb.0 trimb.1 trimb.2 trimb.3 trimb.4 clkc
X0 rstn 1 NOT
X1 en 2 NOT
X2 cal_count.2 3 NOT
X3 cal_count.3 4 NOT
X4 en_co_clk 5 NOT
X5 trim_mask.0 6 NOT
X6 trim_val.4 7 NOT
X7 state.0 8 NOT
X8 state.1 9 NOT
X9 state.2 10 NOT
X10 result.0 11 NOT
X11 result.1 12 NOT
X12 result.2 13 NOT
X13 result.3 14 NOT
X14 result.4 15 NOT
X15 result.5 16 NOT
X16 result.6 17 NOT
X17 result.7 18 NOT
X18 cal_itt.1 19 NOT
X19 cal_itt.2 20 NOT
X20 cal_itt.3 21 NOT
X21 state.0 state.1 22 NOR
X22 8 9 23 NAND
X23 state.2 22 24 NAND
X24 24 valid NOT
X25 state.0 state.2 25 NOR
X26 25 26 NOT
X27 state.1 25 27 NAND
X28 27 28 NOT
X29 8 state.1 29 NOR
X30 state.0 9 30 NAND
X31 10 30 31 NOR
X32 state.2 29 32 NAND
X33 27 32 sample NAND
X34 cal_itt.0 cal_itt.1 33 NAND
X35 33 34 NOT
X36 20 33 35 NOR
X37 cal_itt.2 34 36 NAND
X38 cal_itt.3 36 37 NOR
X39 21 35 38 NAND
X40 6 38 39 NOR
X41 trim_mask.0 37 40 NAND
X42 cal_itt.0 40 41 NAND
X43 31 41 42 NAND
X44 en state.2 43 NOR
X45 43 44 NOT
X46 30 43 45 NOR
X47 29 44 46 NAND
X48 cal_itt.0 46 47 NAND
X49 42 47 48.0 NAND
X50 cal_itt.0 cal_itt.1 49 NOR
X51 19 45 50 NOR
X52 33 39 51 NOR
X53 32 51 52 NOR
X54 50 52 53 NOR
X55 49 53 48.1 NOR
X56 20 33 54 NAND
X57 36 54 55 NAND
X58 40 55 56 NAND
X59 31 56 57 NAND
X60 cal_itt.2 46 58 NAND
X61 57 58 48.2 NAND
X62 8 state.2 59 NOR
X63 59 60 NOT
X64 state.2 30 61 NOR
X65 61 62 NOT
X66 2 62 63 NOR
X67 en 61 64 NAND
X68 31 35 65 NAND
X69 cal_itt.3 65 66 NAND
X70 63 66 48.3 NOR
X71 32 37 67 NOR
X72 31 38 68 NAND
X73 cal_count.0 68 69 NAND
X74 cal_count.0 state.2 70 NAND
X75 45 70 71 NAND
X76 69 71 72.0 NAND
X77 cal_count.1 45 73 NOR
X78 cal_count.0 cal_count.1 74 NAND
X79 comp 74 75 NAND
X80 cal_count.0 cal_count.1 76 NOR
X81 76 77 NOT
X82 comp 74 78 NOR
X83 78 79 NOT
X84 75 77 80 NAND
X85 78 80 81 NOR
X86 comp 76 82 NAND
X87 67 82 83 NAND
X88 81 83 84 NOR
X89 73 84 72.1 NOR
X90 cal_count.2 45 85 NOR
X91 79 82 86 NAND
X92 3 86 87 NAND
X93 67 87 88 NAND
X94 3 86 89 NOR
X95 88 89 90 NOR
X96 85 90 72.2 NOR
X97 cal_count.3 46 91 NAND
X98 cal_count.2 78 92 NAND
X99 92 93 NOT
X100 cal_count.2 82 94 NOR
X101 94 95 NOT
X102 93 94 96 NOR
X103 92 95 97 NAND
X104 4 97 98 NAND
X105 cal_count.3 96 99 NAND
X106 98 99 100 NAND
X107 67 100 101 NAND
X108 91 101 72.3 NAND
X109 5 64 102 NAND
X110 31 40 103 NAND
X111 9 60 104 NOR
X112 state.1 59 105 NAND
X113 mask.0 105 106 NOR
X114 61 106 107 NOR
X115 103 107 108 NAND
X116 102 108 109 NAND
X117 5 29 110 NOR
X118 60 110 111 NAND
X119 109 111 112 NAND
X120 calibrate 27 113 NOR
X121 26 113 114 NOR
X122 32 38 115 NOR
X123 31 37 116 NAND
X124 trim_mask.0 115 117 NAND
X125 4 117 118 NOR
X126 trim_val.0 118 119 NOR
X127 114 119 120.0 NOR
X128 trim_mask.1 115 121 NAND
X129 4 121 122 NOR
X130 trim_val.1 122 123 NOR
X131 114 123 120.1 NOR
X132 trim_mask.2 115 124 NAND
X133 4 124 125 NOR
X134 trim_val.2 125 126 NOR
X135 114 126 120.2 NOR
X136 trim_mask.3 115 127 NAND
X137 4 127 128 NOR
X138 trim_val.3 128 129 NOR
X139 114 129 120.3 NOR
X140 state.2 23 130 NOR
X141 7 114 131 NOR
X142 130 131 132 NOR
X143 trim_mask.4 115 133 NAND
X144 133 134 NOT
X145 cal_count.3 134 135 NAND
X146 132 135 120.4 NAND
X147 calibrate 28 136 NAND
X148 32 136 137 NAND
X149 68 137 138 NAND
X150 trim_mask.0 138 139 NAND
X151 121 139 140.0 NAND
X152 trim_mask.1 138 141 NAND
X153 124 141 140.1 NAND
X154 trim_mask.2 138 142 NAND
X155 127 142 140.2 NAND
X156 trim_mask.3 138 143 NAND
X157 133 143 140.3 NAND
X158 trim_mask.4 116 144 NAND
X159 136 144 140.4 NAND
X160 mask.1 104 145 NAND
X161 29 43 146 NAND
X162 59 146 147 NAND
X163 mask.0 147 148 NAND
X164 145 148 149.0 NAND
X165 mask.2 104 150 NAND
X166 mask.1 147 151 NAND
X167 150 151 149.1 NAND
X168 mask.3 104 152 NAND
X169 mask.2 147 153 NAND
X170 152 153 149.2 NAND
X171 mask.4 104 154 NAND
X172 mask.3 147 155 NAND
X173 154 155 149.3 NAND
X174 mask.5 104 156 NAND
X175 mask.4 147 157 NAND
X176 156 157 149.4 NAND
X177 mask.6 104 158 NAND
X178 mask.5 147 159 NAND
X179 158 159 149.5 NAND
X180 mask.7 104 160 NAND
X181 mask.6 147 161 NAND
X182 160 161 149.6 NAND
X183 mask.7 63 162 NOR
X184 104 162 149.7 NOR
X185 23 27 163 NAND
X186 state.1 state.2 164 NAND
X187 164 165 NOT
X188 103 164 166 NAND
X189 state.0 166 167 NAND
X190 trim_mask.0 116 168 NOR
X191 106 163 169 NOR
X192 146 169 170 NAND
X193 168 170 171 NOR
X194 167 171 172.0 NAND
X195 63 106 173 NOR
X196 113 165 174 NOR
X197 173 174 172.1 NAND
X198 mask.0 104 175 NAND
X199 137 165 176 NOR
X200 175 176 172.2 NAND
X201 cal 63 177 NAND
X202 45 103 178 NAND
X203 calibrate 178 179 NAND
X204 177 179 180 NAND
X205 comp 104 181 NAND
X206 11 181 182 NAND
X207 mask.0 result.0 ctln.0 NOR
X208 ctln.0 ctlp.0 NOT
X209 182 ctlp.0 183 NAND
X210 63 183 184.0 NOR
X211 12 181 185 NAND
X212 mask.1 result.1 ctln.1 NOR
X213 ctln.1 ctlp.1 NOT
X214 185 ctlp.1 186 NAND
X215 63 186 184.1 NOR
X216 13 181 187 NAND
X217 mask.2 result.2 ctln.2 NOR
X218 ctln.2 ctlp.2 NOT
X219 187 ctlp.2 188 NAND
X220 63 188 184.2 NOR
X221 14 181 189 NAND
X222 mask.3 result.3 ctln.3 NOR
X223 ctln.3 ctlp.3 NOT
X224 189 ctlp.3 190 NAND
X225 63 190 184.3 NOR
X226 15 181 191 NAND
X227 mask.4 result.4 ctln.4 NOR
X228 ctln.4 ctlp.4 NOT
X229 191 ctlp.4 192 NAND
X230 63 192 184.4 NOR
X231 16 181 193 NAND
X232 mask.5 result.5 ctln.5 NOR
X233 ctln.5 ctlp.5 NOT
X234 193 ctlp.5 194 NAND
X235 63 194 184.5 NOR
X236 17 181 195 NAND
X237 mask.6 result.6 ctln.6 NOR
X238 ctln.6 ctlp.6 NOT
X239 195 ctlp.6 196 NAND
X240 63 196 184.6 NOR
X241 18 181 197 NAND
X242 mask.7 result.7 ctln.7 NOR
X243 ctln.7 ctlp.7 NOT
X244 197 ctlp.7 198 NAND
X245 63 198 184.7 NOR
X246 trim_mask.0 trim_val.0 trimb.0 NOR
X247 trimb.0 trim.0 NOT
X248 trim_val.1 trim_mask.1 trimb.1 NOR
X249 trimb.1 trim.1 NOT
X250 trim_val.2 trim_mask.2 trimb.2 NOR
X251 trimb.2 trim.2 NOT
X252 trim_val.3 trim_mask.3 trimb.3 NOR
X253 trimb.3 trim.3 NOT
X254 trim_val.4 trim_mask.4 trimb.4 NOR
X255 trimb.4 trim.4 NOT
X256 5 clk clkc NOR
X257 rstn 199 NOT
X258 rstn 200 NOT
X259 rstn 201 NOT
X260 rstn 202 NOT
X261 rstn 203 NOT
X262 rstn 204 NOT
X263 rstn 205 NOT
X264 rstn 206 NOT
X265 rstn 207 NOT
X266 rstn 208 NOT
X267 rstn 209 NOT
X268 rstn 210 NOT
X269 rstn 211 NOT
X270 rstn 212 NOT
X271 rstn 213 NOT
X272 rstn 214 NOT
X273 rstn 215 NOT
X274 rstn 216 NOT
X275 rstn 217 NOT
X276 rstn 218 NOT
X277 rstn 219 NOT
X278 rstn 220 NOT
X279 rstn 221 NOT
X280 rstn 222 NOT
X281 rstn 223 NOT
X282 rstn 224 NOT
X283 rstn 225 NOT
X284 rstn 226 NOT
X285 rstn 227 NOT
X286 rstn 228 NOT
X287 rstn 229 NOT
X288 rstn 230 NOT
X289 rstn 231 NOT
X290 rstn 232 NOT
X291 rstn 233 NOT
X292 rstn 234 NOT
X293 rstn 235 NOT
X294 rstn 236 NOT
X295 clk 184.0 result.0 0s 199 DFFSR
X296 clk 184.1 result.1 0s 200 DFFSR
X297 clk 184.2 result.2 0s 201 DFFSR
X298 clk 184.3 result.3 0s 202 DFFSR
X299 clk 184.4 result.4 0s 203 DFFSR
X300 clk 184.5 result.5 0s 204 DFFSR
X301 clk 184.6 result.6 0s 205 DFFSR
X302 clk 184.7 result.7 0s 206 DFFSR
X303 clk 180 calibrate 0s 207 DFFSR
X304 clk 172.0 state.0 0s 208 DFFSR
X305 clk 172.1 state.1 0s 209 DFFSR
X306 clk 172.2 state.2 0s 210 DFFSR
X307 clk 149.0 mask.0 0s 211 DFFSR
X308 clk 149.1 mask.1 0s 212 DFFSR
X309 clk 149.2 mask.2 0s 213 DFFSR
X310 clk 149.3 mask.3 0s 214 DFFSR
X311 clk 149.4 mask.4 0s 215 DFFSR
X312 clk 149.5 mask.5 0s 216 DFFSR
X313 clk 149.6 mask.6 0s 217 DFFSR
X314 clk 149.7 mask.7 0s 218 DFFSR
X315 clk 140.0 trim_mask.0 0s 219 DFFSR
X316 clk 140.1 trim_mask.1 0s 220 DFFSR
X317 clk 140.2 trim_mask.2 0s 221 DFFSR
X318 clk 140.3 trim_mask.3 0s 222 DFFSR
X319 clk 140.4 trim_mask.4 0s 223 DFFSR
X320 clk 120.0 trim_val.0 0s 224 DFFSR
X321 clk 120.1 trim_val.1 0s 225 DFFSR
X322 clk 120.2 trim_val.2 0s 226 DFFSR
X323 clk 120.3 trim_val.3 0s 227 DFFSR
X324 clk 120.4 trim_val.4 0s 228 DFFSR
X325 clk 112 en_co_clk 0s 229 DFFSR
X326 clk 72.0 cal_count.0 230 0s DFFSR
X327 clk 72.1 cal_count.1 231 0s DFFSR
X328 clk 72.2 cal_count.2 232 0s DFFSR
X329 clk 72.3 cal_count.3 0s 233 DFFSR
X330 clk 48.0 cal_itt.0 0s 234 DFFSR
X331 clk 48.1 cal_itt.1 0s 235 DFFSR
X332 clk 48.2 cal_itt.2 0s 236 DFFSR
X333 clk 48.3 cal_itt.3 0s 1 DFFSR
.ENDS sar_logic

************************
* end of SPICE netlist *
************************
