* SPICE3 file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt M2_1 VSUBS a_40_n109# a_n40_n197# a_n98_n109#
X0 a_40_n109# a_n40_n197# a_n98_n109# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=400000u
.ends

.subckt M2_inv VSUBS a_n98_n104# w_n236_n324# a_40_n104# a_n40_n201#
X0 a_40_n104# a_n40_n201# a_n98_n104# w_n236_n324# sky130_fd_pr__pfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=400000u
.ends

.subckt M1_inv VSUBS a_n98_n171# a_n40_n197# a_40_n171#
X0 a_40_n171# a_n40_n197# a_n98_n171# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=400000u
.ends

.subckt inv_lvt VSUBS m2_289_257# m1_170_505# M1_inv_0/a_n98_n171# M2_inv_0/w_n236_n324#
+ M2_inv_0/a_n98_n104#
XM2_inv_0 VSUBS M2_inv_0/a_n98_n104# M2_inv_0/w_n236_n324# m2_289_257# m1_170_505#
+ M2_inv
XM1_inv_0 VSUBS M1_inv_0/a_n98_n171# m1_170_505# m2_289_257# M1_inv
.ends

.subckt M1_2 VSUBS a_40_n109# a_n40_n197# a_n98_n109#
X0 a_40_n109# a_n40_n197# a_n98_n109# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=400000u
.ends

.subckt latch VSUBS Q R S vdd vss
XM2_1_0 VSUBS Q m1_1673_493# vss M2_1
Xinv_lvt_0 VSUBS m1_1673_493# R vss vdd vdd inv_lvt
Xinv_lvt_1 VSUBS m1_458_623# S vss vdd vdd inv_lvt
Xinv_lvt_2 VSUBS Q Qn vss vdd vdd inv_lvt
Xinv_lvt_3 VSUBS Qn Q vss vdd vdd inv_lvt
XM1_2_0 VSUBS vss m1_458_623# Qn M1_2
.ends

.subckt inv2 VSUBS a_67_55# a_149_55# a_59_207# a_67_305# w_0_269#
X0 a_67_305# a_59_207# a_149_55# w_0_269# sky130_fd_pr__pfet_01v8_hvt ad=5.2e+11p pd=5.04e+06u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X1 a_67_55# a_59_207# a_149_55# VSUBS sky130_fd_pr__nfet_01v8 ad=3.38e+11p pd=3.64e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X2 a_149_55# a_59_207# a_67_55# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 a_149_55# a_59_207# a_67_305# w_0_269# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt decap_8 VSUBS w_0_269# a_65_331# a_65_55#
X0 a_65_55# a_65_331# a_65_55# VSUBS sky130_fd_pr__nfet_01v8 ad=2.86e+11p pd=3.24e+06u as=0p ps=0u w=550000u l=2.89e+06u
X1 a_65_331# a_65_55# a_65_331# w_0_269# sky130_fd_pr__pfet_01v8_hvt ad=4.524e+11p pd=4.52e+06u as=0p ps=0u w=870000u l=2.89e+06u
.ends

.subckt M1_3 VSUBS a_n147_n176# a_325_n176# w_n757_n324# a_n92_55# a_n619_n176# a_380_55#
+ a_262_55# a_n265_n176# a_443_n176# a_144_55# a_498_55# a_n383_n176# a_561_n176#
+ a_n501_n176# a_n210_55# a_n564_55# a_n446_55# a_89_n176# a_n328_55# a_26_55# a_n29_n176#
+ a_207_n176#
X0 a_n265_n176# a_n328_55# a_n383_n176# w_n757_n324# sky130_fd_pr__pfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
X1 a_n147_n176# a_n210_55# a_n265_n176# w_n757_n324# sky130_fd_pr__pfet_01v8 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=300000u
X2 a_561_n176# a_498_55# a_443_n176# w_n757_n324# sky130_fd_pr__pfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
X3 a_443_n176# a_380_55# a_325_n176# w_n757_n324# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
X4 a_325_n176# a_262_55# a_207_n176# w_n757_n324# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
X5 a_207_n176# a_144_55# a_89_n176# w_n757_n324# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
X6 a_n29_n176# a_n92_55# a_n147_n176# w_n757_n324# sky130_fd_pr__pfet_01v8 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=300000u
X7 a_89_n176# a_26_55# a_n29_n176# w_n757_n324# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1e+06u l=300000u
X8 a_n501_n176# a_n564_55# a_n619_n176# w_n757_n324# sky130_fd_pr__pfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
X9 a_n383_n176# a_n446_55# a_n501_n176# w_n757_n324# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1e+06u l=300000u
.ends

.subckt M2_2 VSUBS a_n29_n171# a_207_n171# a_n147_n171# a_325_n171# a_n92_51# a_380_51#
+ a_n619_n171# a_262_51# a_n265_n171# a_144_51# a_443_n171# a_498_51# a_n383_n171#
+ a_561_n171# a_n210_51# a_n501_n171# a_n564_51# a_n446_51# a_n328_51# a_89_n171#
+ w_n747_n309# a_26_51#
X0 a_n501_n171# a_n564_51# a_n619_n171# VSUBS sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
X1 a_n383_n171# a_n446_51# a_n501_n171# VSUBS sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=300000u
X2 a_n265_n171# a_n328_51# a_n383_n171# VSUBS sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=300000u
X3 a_n147_n171# a_n210_51# a_n265_n171# VSUBS sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=300000u
X4 a_561_n171# a_498_51# a_443_n171# VSUBS sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
X5 a_443_n171# a_380_51# a_325_n171# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
X6 a_325_n171# a_262_51# a_207_n171# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
X7 a_207_n171# a_144_51# a_89_n171# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
X8 a_n29_n171# a_n92_51# a_n147_n171# VSUBS sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=300000u
X9 a_89_n171# a_26_51# a_n29_n171# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=1e+06u l=300000u
.ends

.subckt inv_4 VSUBS a_157_55# a_75_305# a_75_55# a_59_207# w_0_269#
X0 a_157_55# a_59_207# a_75_55# VSUBS sky130_fd_pr__nfet_01v8 ad=3.51e+11p pd=3.68e+06u as=5.135e+11p ps=5.48e+06u w=650000u l=150000u
X1 a_157_55# a_59_207# a_75_305# w_0_269# sky130_fd_pr__pfet_01v8_hvt ad=5.4e+11p pd=5.08e+06u as=7.9e+11p ps=7.58e+06u w=1e+06u l=150000u
X2 a_157_55# a_59_207# a_75_55# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 a_157_55# a_59_207# a_75_305# w_0_269# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_75_305# a_59_207# a_157_55# w_0_269# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_75_55# a_59_207# a_157_55# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_75_55# a_59_207# a_157_55# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 a_75_305# a_59_207# a_157_55# w_0_269# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt decap_3 VSUBS w_0_269# a_65_331# a_65_55#
X0 a_65_55# a_65_331# a_65_55# VSUBS sky130_fd_pr__nfet_01v8 ad=2.86e+11p pd=3.24e+06u as=0p ps=0u w=550000u l=590000u
X1 a_65_331# a_65_55# a_65_331# w_0_269# sky130_fd_pr__pfet_01v8_hvt ad=4.524e+11p pd=4.52e+06u as=0p ps=0u w=870000u l=590000u
.ends

.subckt sw_top VSUBS inv_4_1/w_0_269# in vdd en out vss m2_990_200# m2_1158_361#
Xdecap_8_0 VSUBS inv_4_1/w_0_269# vdd vss decap_8
XM1_3_0 VSUBS in in vdd m2_1158_361# in m2_1158_361# m2_1158_361# out out m2_1158_361#
+ m2_1158_361# in in out m2_1158_361# m2_1158_361# m2_1158_361# in m2_1158_361# m2_1158_361#
+ out out M1_3
XM2_2_0 VSUBS out out in in m2_990_200# m2_990_200# in m2_990_200# out m2_990_200#
+ out m2_990_200# in in m2_990_200# out m2_990_200# m2_990_200# m2_990_200# in vss
+ m2_990_200# M2_2
Xinv_4_0 VSUBS m2_990_200# vdd vss m2_1158_361# inv_4_1/w_0_269# inv_4
Xinv_4_1 VSUBS m2_1158_361# vdd vss en inv_4_1/w_0_269# inv_4
Xdecap_3_0 VSUBS inv_4_1/w_0_269# vdd vss decap_3
.ends

.subckt C7 VSUBS c1_n250_n240# m3_n450_n340#
X0 c1_n250_n240# m3_n450_n340# sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
.ends

.subckt DUMMY VSUBS c1_n250_n240# m3_n450_n340#
X0 c1_n250_n240# m3_n450_n340# sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
.ends

.subckt C6 VSUBS c1_n250_n240# m3_n450_n340#
X0 c1_n250_n240# m3_n450_n340# sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
.ends

.subckt CDUM VSUBS c1_n250_n240# m3_n450_n340#
X0 c1_n250_n240# m3_n450_n340# sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
.ends

.subckt C4 VSUBS c1_n250_n240# m3_n450_n340#
X0 c1_n250_n240# m3_n450_n340# sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
.ends

.subckt C2 VSUBS c1_n250_n240# m3_n450_n340#
X0 c1_n250_n240# m3_n450_n340# sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
.ends

.subckt C5 VSUBS c1_n250_n240# m3_n450_n340#
X0 c1_n250_n240# m3_n450_n340# sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
.ends

.subckt C3 VSUBS c1_n250_n240# m3_n450_n340#
X0 c1_n250_n240# m3_n450_n340# sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
.ends

.subckt C1 VSUBS c1_n250_n240# m3_n450_n340#
X0 c1_n250_n240# m3_n450_n340# sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
.ends

.subckt C0_1 VSUBS c1_n250_n240# m3_n450_n340#
X0 c1_n250_n240# m3_n450_n340# sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
.ends

.subckt carray VSUBS n0 n1 n2 n3 n4 n5 n6 n7 ndum top
XC7_121 VSUBS top n7 C7
XC7_110 VSUBS top n7 C7
XDUMMY_80 VSUBS top via23_4_721/m2_1_40# DUMMY
XC6_53 VSUBS top n6 C6
XC6_42 VSUBS top n6 C6
XC6_31 VSUBS top n6 C6
XC6_20 VSUBS top n6 C6
XC7_122 VSUBS top n7 C7
XC7_111 VSUBS top n7 C7
XC7_100 VSUBS top n7 C7
XDUMMY_81 VSUBS top via23_4_718/m2_1_40# DUMMY
XDUMMY_70 VSUBS top via23_4_651/m2_1_40# DUMMY
XC6_10 VSUBS top n6 C6
XC6_21 VSUBS top n6 C6
XC6_54 VSUBS top n6 C6
XC6_43 VSUBS top n6 C6
XC6_32 VSUBS top n6 C6
XC6_0 VSUBS top n6 C6
XC7_123 VSUBS top n7 C7
XC7_112 VSUBS top n7 C7
XC7_101 VSUBS top n7 C7
XDUMMY_82 VSUBS top via23_4_441/m2_1_40# DUMMY
XDUMMY_71 VSUBS top via23_4_650/m2_1_40# DUMMY
XDUMMY_60 VSUBS top via23_4_451/m2_1_40# DUMMY
XC6_55 VSUBS top n6 C6
XC6_44 VSUBS top n6 C6
XC6_33 VSUBS top n6 C6
XC6_11 VSUBS top n6 C6
XC6_22 VSUBS top n6 C6
XC6_1 VSUBS top n6 C6
XC7_124 VSUBS top n7 C7
XC7_113 VSUBS top n7 C7
XC7_102 VSUBS top n7 C7
XDUMMY_83 VSUBS top via23_4_684/m2_1_40# DUMMY
XDUMMY_72 VSUBS top via23_4_685/m2_1_40# DUMMY
XDUMMY_61 VSUBS top via23_4_597/m2_1_40# DUMMY
XDUMMY_50 VSUBS top via23_4_431/m2_1_40# DUMMY
XC6_56 VSUBS top n6 C6
XC6_45 VSUBS top n6 C6
XC6_34 VSUBS top n6 C6
XC6_23 VSUBS top n6 C6
XC6_12 VSUBS top n6 C6
XC6_2 VSUBS top n6 C6
XCDUM_0 VSUBS top ndum CDUM
XC7_125 VSUBS top n7 C7
XC7_114 VSUBS top n7 C7
XC7_103 VSUBS top n7 C7
XDUMMY_73 VSUBS top via23_4_686/m2_1_40# DUMMY
XDUMMY_62 VSUBS top via23_4_598/m2_1_40# DUMMY
XDUMMY_51 VSUBS top via23_4_416/m2_1_40# DUMMY
XDUMMY_40 VSUBS top via23_4_328/m2_1_40# DUMMY
XC6_57 VSUBS top n6 C6
XC6_46 VSUBS top n6 C6
XC6_35 VSUBS top n6 C6
XC6_24 VSUBS top n6 C6
XC6_13 VSUBS top n6 C6
XDUMMY_0 VSUBS top via23_4_3/m2_1_40# DUMMY
XC6_3 VSUBS top n6 C6
XC4_0 VSUBS top n4 C4
XC7_104 VSUBS top n7 C7
XC7_126 VSUBS top n7 C7
XC7_115 VSUBS top n7 C7
XDUMMY_74 VSUBS top via23_4_687/m2_1_40# DUMMY
XDUMMY_63 VSUBS top via23_4_599/m2_1_40# DUMMY
XDUMMY_52 VSUBS top via23_4_383/m2_1_40# DUMMY
XDUMMY_41 VSUBS top via23_4_90/m2_1_40# DUMMY
XDUMMY_30 VSUBS top via23_4_252/m2_1_40# DUMMY
XC6_58 VSUBS top n6 C6
XC6_47 VSUBS top n6 C6
XC6_36 VSUBS top n6 C6
XC6_25 VSUBS top n6 C6
XC6_14 VSUBS top n6 C6
XDUMMY_1 VSUBS top via23_4_9/m2_1_40# DUMMY
XC7_90 VSUBS top n7 C7
XC6_4 VSUBS top n6 C6
XC4_1 VSUBS top n4 C4
XC7_127 VSUBS top n7 C7
XC7_116 VSUBS top n7 C7
XC7_105 VSUBS top n7 C7
XDUMMY_20 VSUBS top via23_4_200/m2_1_40# DUMMY
XDUMMY_75 VSUBS top via23_4_713/m2_1_40# DUMMY
XDUMMY_64 VSUBS top via23_4_593/m2_1_40# DUMMY
XDUMMY_53 VSUBS top via23_4_452/m2_1_40# DUMMY
XDUMMY_42 VSUBS top via23_4_368/m2_1_40# DUMMY
XDUMMY_31 VSUBS top via23_4_246/m2_1_40# DUMMY
XC6_26 VSUBS top n6 C6
XC6_15 VSUBS top n6 C6
XC6_59 VSUBS top n6 C6
XC6_48 VSUBS top n6 C6
XC6_37 VSUBS top n6 C6
XDUMMY_2 VSUBS top via23_4_1/m2_1_40# DUMMY
XC7_91 VSUBS top n7 C7
XC7_80 VSUBS top n7 C7
XC6_5 VSUBS top n6 C6
XC4_2 VSUBS top n4 C4
XC7_117 VSUBS top n7 C7
XC7_106 VSUBS top n7 C7
XDUMMY_76 VSUBS top via23_4_711/m2_1_40# DUMMY
XDUMMY_65 VSUBS top via23_4_609/m2_1_40# DUMMY
XDUMMY_54 VSUBS top via23_4_449/m2_1_40# DUMMY
XDUMMY_43 VSUBS top via23_4_369/m2_1_40# DUMMY
XDUMMY_32 VSUBS top via23_4_333/m2_1_40# DUMMY
XDUMMY_10 VSUBS top via23_4_91/m2_1_40# DUMMY
XDUMMY_21 VSUBS top via23_4_199/m2_1_40# DUMMY
XC6_49 VSUBS top n6 C6
XC6_38 VSUBS top n6 C6
XC6_27 VSUBS top n6 C6
XC6_16 VSUBS top n6 C6
XDUMMY_3 VSUBS top via23_4_2/m2_1_40# DUMMY
XC7_92 VSUBS top n7 C7
XC7_81 VSUBS top n7 C7
XC7_70 VSUBS top n7 C7
XC6_6 VSUBS top n6 C6
XC4_3 VSUBS top n4 C4
XC7_118 VSUBS top n7 C7
XC7_107 VSUBS top n7 C7
XC2_0 VSUBS top n2 C2
XDUMMY_77 VSUBS top via23_4_714/m2_1_40# DUMMY
XDUMMY_66 VSUBS top via23_4_610/m2_1_40# DUMMY
XDUMMY_55 VSUBS top via23_4_450/m2_1_40# DUMMY
XDUMMY_44 VSUBS top via23_4_370/m2_1_40# DUMMY
XDUMMY_33 VSUBS top via23_4_334/m2_1_40# DUMMY
XDUMMY_11 VSUBS top via23_4_97/m2_1_40# DUMMY
XDUMMY_22 VSUBS top via23_4_221/m2_1_40# DUMMY
XC6_39 VSUBS top n6 C6
XC6_28 VSUBS top n6 C6
XC6_17 VSUBS top n6 C6
XDUMMY_4 VSUBS top via23_4_20/m2_1_40# DUMMY
XC7_93 VSUBS top n7 C7
XC7_82 VSUBS top n7 C7
XC7_71 VSUBS top n7 C7
XC7_60 VSUBS top n7 C7
XC6_7 VSUBS top n6 C6
XC4_4 VSUBS top n4 C4
XC7_119 VSUBS top n7 C7
XC7_108 VSUBS top n7 C7
XC2_1 VSUBS top n2 C2
XDUMMY_78 VSUBS top via23_4_719/m2_1_40# DUMMY
XDUMMY_67 VSUBS top via23_4_608/m2_1_40# DUMMY
XDUMMY_56 VSUBS top via23_4_461/m2_1_40# DUMMY
XDUMMY_45 VSUBS top via23_4_371/m2_1_40# DUMMY
XDUMMY_34 VSUBS top via23_4_335/m2_1_40# DUMMY
XDUMMY_12 VSUBS top via23_4_104/m2_1_40# DUMMY
XDUMMY_23 VSUBS top via23_4_214/m2_1_40# DUMMY
XC6_29 VSUBS top n6 C6
XC6_18 VSUBS top n6 C6
XDUMMY_5 VSUBS top via23_4_21/m2_1_40# DUMMY
XC7_94 VSUBS top n7 C7
XC7_83 VSUBS top n7 C7
XC7_72 VSUBS top n7 C7
XC7_61 VSUBS top n7 C7
XC7_50 VSUBS top n7 C7
XC6_8 VSUBS top n6 C6
XC4_5 VSUBS top n4 C4
XC7_109 VSUBS top n7 C7
XC2_2 VSUBS top n2 C2
XDUMMY_79 VSUBS top via23_4_720/m2_1_40# DUMMY
XDUMMY_68 VSUBS top via23_4_607/m2_1_40# DUMMY
XDUMMY_57 VSUBS top via23_4_458/m2_1_40# DUMMY
XDUMMY_46 VSUBS top via23_4_380/m2_1_40# DUMMY
XDUMMY_35 VSUBS top via23_4_349/m2_1_40# DUMMY
XDUMMY_13 VSUBS top via23_4_92/m2_1_40# DUMMY
XDUMMY_24 VSUBS top via23_4_230/m2_1_40# DUMMY
XC6_19 VSUBS top n6 C6
XDUMMY_6 VSUBS top via23_4_22/m2_1_40# DUMMY
XC7_95 VSUBS top n7 C7
XC7_84 VSUBS top n7 C7
XC7_73 VSUBS top n7 C7
XC7_62 VSUBS top n7 C7
XC7_51 VSUBS top n7 C7
XC7_40 VSUBS top n7 C7
XC6_9 VSUBS top n6 C6
XC4_6 VSUBS top n4 C4
XC2_3 VSUBS top n2 C2
XDUMMY_36 VSUBS top via23_4_356/m2_1_40# DUMMY
XDUMMY_14 VSUBS top via23_4_95/m2_1_40# DUMMY
XDUMMY_25 VSUBS top via23_4_229/m2_1_40# DUMMY
XDUMMY_69 VSUBS top via23_4_644/m2_1_40# DUMMY
XDUMMY_58 VSUBS top via23_4_462/m2_1_40# DUMMY
XDUMMY_47 VSUBS top via23_4_381/m2_1_40# DUMMY
XDUMMY_7 VSUBS top via23_4_23/m2_1_40# DUMMY
XC7_96 VSUBS top n7 C7
XC7_85 VSUBS top n7 C7
XC7_74 VSUBS top n7 C7
XC7_63 VSUBS top n7 C7
XC7_52 VSUBS top n7 C7
XC7_30 VSUBS top n7 C7
XC7_41 VSUBS top n7 C7
XC4_7 VSUBS top n4 C4
XDUMMY_59 VSUBS top via23_4_463/m2_1_40# DUMMY
XDUMMY_48 VSUBS top via23_4_382/m2_1_40# DUMMY
XDUMMY_37 VSUBS top via23_4_347/m2_1_40# DUMMY
XDUMMY_15 VSUBS top via23_4_118/m2_1_40# DUMMY
XDUMMY_26 VSUBS top via23_4_231/m2_1_40# DUMMY
XDUMMY_8 VSUBS top via23_4_88/m2_1_40# DUMMY
XC7_97 VSUBS top n7 C7
XC7_86 VSUBS top n7 C7
XC7_75 VSUBS top n7 C7
XC7_64 VSUBS top n7 C7
XC7_53 VSUBS top n7 C7
XC7_20 VSUBS top n7 C7
XC7_31 VSUBS top n7 C7
XC7_42 VSUBS top n7 C7
XC4_10 VSUBS top n4 C4
XC4_8 VSUBS top n4 C4
XDUMMY_49 VSUBS top via23_4_421/m2_1_40# DUMMY
XDUMMY_38 VSUBS top via23_4_348/m2_1_40# DUMMY
XDUMMY_16 VSUBS top via23_4_112/m2_1_40# DUMMY
XDUMMY_27 VSUBS top via23_4_219/m2_1_40# DUMMY
XDUMMY_9 VSUBS top via23_4_89/m2_1_40# DUMMY
XC7_98 VSUBS top n7 C7
XC7_87 VSUBS top n7 C7
XC7_76 VSUBS top n7 C7
XC7_65 VSUBS top n7 C7
XC7_54 VSUBS top n7 C7
XC7_10 VSUBS top n7 C7
XC7_21 VSUBS top n7 C7
XC7_32 VSUBS top n7 C7
XC7_43 VSUBS top n7 C7
XC4_11 VSUBS top n4 C4
XC4_9 VSUBS top n4 C4
XDUMMY_39 VSUBS top via23_4_336/m2_1_40# DUMMY
XDUMMY_17 VSUBS top via23_4_129/m2_1_40# DUMMY
XDUMMY_28 VSUBS top via23_4_250/m2_1_40# DUMMY
XC7_99 VSUBS top n7 C7
XC7_88 VSUBS top n7 C7
XC7_77 VSUBS top n7 C7
XC7_66 VSUBS top n7 C7
XC7_55 VSUBS top n7 C7
XC7_11 VSUBS top n7 C7
XC7_22 VSUBS top n7 C7
XC7_33 VSUBS top n7 C7
XC7_44 VSUBS top n7 C7
XC4_12 VSUBS top n4 C4
XDUMMY_18 VSUBS top via23_4_96/m2_1_40# DUMMY
XDUMMY_29 VSUBS top via23_4_251/m2_1_40# DUMMY
XC7_89 VSUBS top n7 C7
XC7_78 VSUBS top n7 C7
XC7_67 VSUBS top n7 C7
XC7_56 VSUBS top n7 C7
XC7_12 VSUBS top n7 C7
XC7_23 VSUBS top n7 C7
XC7_34 VSUBS top n7 C7
XC7_45 VSUBS top n7 C7
XC4_13 VSUBS top n4 C4
XDUMMY_19 VSUBS top via23_4_201/m2_1_40# DUMMY
XC7_79 VSUBS top n7 C7
XC7_68 VSUBS top n7 C7
XC7_57 VSUBS top n7 C7
XC7_13 VSUBS top n7 C7
XC7_24 VSUBS top n7 C7
XC7_35 VSUBS top n7 C7
XC7_46 VSUBS top n7 C7
XC4_14 VSUBS top n4 C4
XC7_69 VSUBS top n7 C7
XC7_58 VSUBS top n7 C7
XC7_14 VSUBS top n7 C7
XC7_25 VSUBS top n7 C7
XC7_36 VSUBS top n7 C7
XC7_47 VSUBS top n7 C7
XC4_15 VSUBS top n4 C4
XC7_0 VSUBS top n7 C7
XC7_59 VSUBS top n7 C7
XC7_15 VSUBS top n7 C7
XC7_26 VSUBS top n7 C7
XC7_37 VSUBS top n7 C7
XC7_48 VSUBS top n7 C7
XC7_1 VSUBS top n7 C7
XC7_49 VSUBS top n7 C7
XC7_16 VSUBS top n7 C7
XC7_27 VSUBS top n7 C7
XC7_38 VSUBS top n7 C7
XC7_2 VSUBS top n7 C7
XC7_17 VSUBS top n7 C7
XC7_28 VSUBS top n7 C7
XC7_39 VSUBS top n7 C7
XC7_3 VSUBS top n7 C7
XC5_0 VSUBS top n5 C5
XC7_18 VSUBS top n7 C7
XC7_29 VSUBS top n7 C7
XC7_4 VSUBS top n7 C7
XC5_1 VSUBS top n5 C5
XC7_19 VSUBS top n7 C7
XC5_30 VSUBS top n5 C5
XC7_5 VSUBS top n7 C7
XC5_2 VSUBS top n5 C5
XC5_31 VSUBS top n5 C5
XC5_20 VSUBS top n5 C5
XC7_6 VSUBS top n7 C7
XC5_3 VSUBS top n5 C5
XC3_0 VSUBS top n3 C3
XC5_21 VSUBS top n5 C5
XC5_10 VSUBS top n5 C5
XC7_7 VSUBS top n7 C7
XC5_4 VSUBS top n5 C5
XC3_1 VSUBS top n3 C3
XC5_22 VSUBS top n5 C5
XC5_11 VSUBS top n5 C5
XC7_8 VSUBS top n7 C7
XC5_5 VSUBS top n5 C5
XC3_2 VSUBS top n3 C3
XC5_23 VSUBS top n5 C5
XC5_12 VSUBS top n5 C5
XC7_9 VSUBS top n7 C7
XC5_6 VSUBS top n5 C5
XC3_3 VSUBS top n3 C3
XC1_0 VSUBS top n1 C1
XC5_24 VSUBS top n5 C5
XC5_13 VSUBS top n5 C5
XC5_7 VSUBS top n5 C5
XC3_4 VSUBS top n3 C3
XC1_1 VSUBS top n1 C1
XC5_25 VSUBS top n5 C5
XC5_14 VSUBS top n5 C5
XC5_8 VSUBS top n5 C5
XC3_5 VSUBS top n3 C3
XC5_26 VSUBS top n5 C5
XC5_15 VSUBS top n5 C5
XC5_9 VSUBS top n5 C5
XC3_6 VSUBS top n3 C3
XC5_27 VSUBS top n5 C5
XC5_16 VSUBS top n5 C5
XC3_7 VSUBS top n3 C3
XC0_1_0 VSUBS top n0 C0_1
XC5_28 VSUBS top n5 C5
XC5_17 VSUBS top n5 C5
XC6_60 VSUBS top n6 C6
XC5_29 VSUBS top n5 C5
XC5_18 VSUBS top n5 C5
XC6_61 VSUBS top n6 C6
XC6_50 VSUBS top n6 C6
XC5_19 VSUBS top n5 C5
XC6_62 VSUBS top n6 C6
XC6_51 VSUBS top n6 C6
XC6_40 VSUBS top n6 C6
XC7_120 VSUBS top n7 C7
XC6_63 VSUBS top n6 C6
XC6_52 VSUBS top n6 C6
XC6_41 VSUBS top n6 C6
XC6_30 VSUBS top n6 C6
.ends

.subckt DAC VSUBS ctl7 vdd dum out sample vss ctl0 ctl1 ctl2 ctl3 vin ctl4 ctl5 tap_2/w_0_309#
+ ctl6
Xinv2_0 VSUBS vss carray_0/n7 ctl7 vdd inv2_8/w_0_269# inv2
Xinv2_1 VSUBS vss carray_0/n6 ctl6 vdd inv2_8/w_0_269# inv2
Xinv2_2 VSUBS vss carray_0/ndum dum vdd inv2_8/w_0_269# inv2
Xinv2_3 VSUBS vss carray_0/n0 ctl0 vdd inv2_8/w_0_269# inv2
Xinv2_4 VSUBS vss carray_0/n1 ctl1 vdd inv2_8/w_0_269# inv2
Xinv2_5 VSUBS vss carray_0/n5 ctl5 vdd inv2_8/w_0_269# inv2
Xinv2_6 VSUBS vss carray_0/n4 ctl4 vdd inv2_8/w_0_269# inv2
Xinv2_7 VSUBS vss carray_0/n2 ctl2 vdd inv2_8/w_0_269# inv2
Xinv2_8 VSUBS vss carray_0/n3 ctl3 vdd inv2_8/w_0_269# inv2
Xsw_top_0 VSUBS tap_2/w_0_309# vin vdd sample out vss sw_top_0/m2_990_200# sw_top_0/m2_1158_361#
+ sw_top
Xcarray_0 VSUBS carray_0/n0 carray_0/n1 carray_0/n2 carray_0/n3 carray_0/n4 carray_0/n5
+ carray_0/n6 carray_0/n7 carray_0/ndum out carray
Xsw_top_1 VSUBS tap_2/w_0_309# vin vdd sample out vss en_buf enb sw_top
Xsw_top_2 VSUBS tap_2/w_0_309# vin vdd sample out vss en_buf enb sw_top
Xsw_top_3 VSUBS tap_2/w_0_309# vin vdd sample out vss sw_top_3/m2_990_200# sw_top_3/m2_1158_361#
+ sw_top
.ends

.subckt decap_3$1 VSUBS w_0_269# a_65_331# a_65_55#
X0 a_65_55# a_65_331# a_65_55# VSUBS sky130_fd_pr__nfet_01v8 ad=2.86e+11p pd=3.24e+06u as=0p ps=0u w=550000u l=590000u
X1 a_65_331# a_65_55# a_65_331# w_0_269# sky130_fd_pr__pfet_01v8_hvt ad=4.524e+11p pd=4.52e+06u as=0p ps=0u w=870000u l=590000u
.ends

.subckt M1_1 VSUBS a_n33_n197# a_n88_n109# w_n114_n135# a_30_n109#
X0 a_30_n109# a_n33_n197# a_n88_n109# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
.ends

.subckt trim_sw VSUBS d_0 d_1 d_2 d_3 d_4 m1_1226_409# m1_799_409# m1_136_409# m1_1771_409#
+ vss m1_1462_409#
XM1_1_14 VSUBS d_2 m1_799_409# M1_1_15/w_n114_n135# vss M1_1
XM1_1_15 VSUBS d_2 vss M1_1_15/w_n114_n135# m1_799_409# M1_1
XM1_1_0 VSUBS d_0 m1_1226_409# M1_1_9/w_n114_n135# vss M1_1
XM1_1_1 VSUBS d_4 m1_1771_409# M1_1_8/w_n114_n135# vss M1_1
XM1_1_2 VSUBS d_4 vss M1_1_8/w_n114_n135# m1_1771_409# M1_1
XM1_1_3 VSUBS d_4 m1_1771_409# M1_1_8/w_n114_n135# vss M1_1
XM1_1_4 VSUBS d_4 vss M1_1_8/w_n114_n135# m1_1771_409# M1_1
XM1_1_5 VSUBS d_4 vss M1_1_8/w_n114_n135# m1_1771_409# M1_1
XM1_1_6 VSUBS d_4 m1_1771_409# M1_1_8/w_n114_n135# vss M1_1
XM1_1_7 VSUBS d_4 m1_1771_409# M1_1_8/w_n114_n135# vss M1_1
XM1_1_9 VSUBS d_1 vss M1_1_9/w_n114_n135# m1_1462_409# M1_1
XM1_1_8 VSUBS d_4 vss M1_1_8/w_n114_n135# m1_1771_409# M1_1
XM1_1_10 VSUBS d_3 vss M1_1_13/w_n114_n135# m1_136_409# M1_1
XM1_1_11 VSUBS d_3 m1_136_409# M1_1_13/w_n114_n135# vss M1_1
XM1_1_12 VSUBS d_3 vss M1_1_13/w_n114_n135# m1_136_409# M1_1
XM1_1_13 VSUBS d_3 m1_136_409# M1_1_13/w_n114_n135# vss M1_1
.ends

.subckt trim drain VSUBS trim_sw_0/d_0 trim_sw_0/d_1 trim_sw_0/d_2 trim_sw_0/d_3 trim_sw_0/d_4
+ trim_sw_0/vss
Xtrim_sw_0 VSUBS trim_sw_0/d_0 trim_sw_0/d_1 trim_sw_0/d_2 trim_sw_0/d_3 trim_sw_0/d_4
+ n0 n2 n3 n4 trim_sw_0/vss n1 trim_sw
.ends

.subckt Mdiff VSUBS a_n88_n171# a_30_n171# w_n114_n197# a_n33_51#
X0 a_30_n171# a_n33_51# a_n88_n171# VSUBS sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
.ends

.subckt M3 VSUBS a_30_n176# w_n124_n238# a_n33_55# a_n88_n176#
X0 a_30_n176# a_n33_55# a_n88_n176# w_n124_n238# sky130_fd_pr__pfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
.ends

.subckt Ml1 VSUBS a_n88_n171# a_30_n171# w_n114_n197# a_n33_51#
X0 a_30_n171# a_n33_51# a_n88_n171# VSUBS sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
.ends

.subckt Minp VSUBS a_n88_n171# a_30_n171# w_n114_n197# a_n33_51#
X0 a_30_n171# a_n33_51# a_n88_n171# VSUBS sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
.ends

.subckt M1 VSUBS a_30_n176# w_n124_n238# a_n33_55# a_n88_n176#
X0 a_30_n176# a_n33_55# a_n88_n176# w_n124_n238# sky130_fd_pr__pfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
.ends

.subckt Minn VSUBS a_n88_n171# a_30_n171# w_n114_n197# a_n33_51#
X0 a_30_n171# a_n33_51# a_n88_n171# VSUBS sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
.ends

.subckt Ml4 VSUBS a_30_n176# w_n124_n238# a_n33_55# a_n88_n176#
X0 a_30_n176# a_n33_55# a_n88_n176# w_n124_n238# sky130_fd_pr__pfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
.ends

.subckt M4 VSUBS a_30_n176# w_n124_n238# a_n33_55# a_n88_n176#
X0 a_30_n176# a_n33_55# a_n88_n176# w_n124_n238# sky130_fd_pr__pfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
.ends

.subckt Ml2 VSUBS a_n88_n171# a_30_n171# w_n114_n197# a_n33_51#
X0 a_30_n171# a_n33_51# a_n88_n171# VSUBS sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
.ends

.subckt M2 VSUBS a_30_n176# w_n124_n238# a_n33_55# a_n88_n176#
X0 a_30_n176# a_n33_55# a_n88_n176# w_n124_n238# sky130_fd_pr__pfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
.ends

.subckt Ml3 VSUBS a_30_n176# w_n124_n238# a_n33_55# a_n88_n176#
X0 a_30_n176# a_n33_55# a_n88_n176# w_n124_n238# sky130_fd_pr__pfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
.ends

.subckt comparator_core VSUBS clk in ip vdd vss vn vp outn outp
XMdiff_0 VSUBS diff vss Mdiff_1/w_n114_n197# clk Mdiff
XMdiff_1 VSUBS vss diff Mdiff_1/w_n114_n197# clk Mdiff
XM3_0 VSUBS vdd w_302_2337# clk outp M3
XMl1_0 VSUBS in outn Ml2_0/w_n114_n197# outp Ml1
XMinp_0 VSUBS diff ip Ml2_0/w_n114_n197# vp Minp
XM1_0 VSUBS vdd w_302_2337# clk in M1
XMinn_0 VSUBS in diff Ml2_0/w_n114_n197# vn Minn
XMl4_0 VSUBS outp w_302_2337# outn vdd Ml4
XM4_0 VSUBS ip w_302_2337# clk vdd M4
XMl2_0 VSUBS outp ip Ml2_0/w_n114_n197# outn Ml2
XM2_0 VSUBS outn w_302_2337# clk vdd M2
XMl3_0 VSUBS vdd w_302_2337# outp outn Ml3
.ends

.subckt comparator VSUBS clk vss vn vp trim_0 trim_1 trim_2 trim_3 trim_4 vdd trimb_0
+ outn trimb_1 trimb_2 outp trimb_3 trimb_4
Xtrim_0 trim_0/drain VSUBS trim_0 trim_1 trim_2 trim_3 trim_4 vss trim
Xtrim_1 trim_1/drain VSUBS trimb_0 trimb_1 trimb_2 trimb_3 trimb_4 vss trim
Xcomparator_core_0 VSUBS clk trim_0/drain trim_1/drain vdd vss vn vp outn outp comparator_core
.ends

.subckt sky130_fd_sc_hd__decap_8 VGND VPWR VPB VNB
X0 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=2.86e+11p pd=3.24e+06u as=0p ps=0u w=550000u l=2.89e+06u
X1 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=4.524e+11p pd=4.52e+06u as=0p ps=0u w=870000u l=2.89e+06u
.ends

.subckt sky130_fd_sc_hd__decap_4 VGND VPWR VPB VNB
X0 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=2.86e+11p pd=3.24e+06u as=0p ps=0u w=550000u l=1.05e+06u
X1 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=4.524e+11p pd=4.52e+06u as=0p ps=0u w=870000u l=1.05e+06u
.ends

.subckt sky130_fd_sc_hd__inv_2 VGND Y VPWR A VPB VNB
X0 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=3.38e+11p pd=3.64e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X1 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=5.2e+11p pd=5.04e+06u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X2 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__dfstp_1 Q VGND SET_B CLK VPWR VPB VNB D
X0 a_562_373# a_27_7# a_476_7# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.89e+11p pd=1.74e+06u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X1 VPWR CLK a_27_7# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.3171e+12p pd=1.335e+07u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X2 a_193_7# a_27_7# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=1.664e+11p pd=1.8e+06u as=0p ps=0u w=640000u l=150000u
X3 a_1056_7# a_476_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=9.868e+11p ps=1.019e+07u w=420000u l=150000u
X4 VGND SET_B a_1296_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=9.66e+10p ps=1.3e+06u w=420000u l=150000u
X5 a_381_7# D VGND VNB sky130_fd_pr__nfet_01v8 ad=1.87e+11p pd=1.93e+06u as=0p ps=0u w=640000u l=150000u
X6 a_1182_221# a_1032_373# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.404e+11p pd=1.6e+06u as=0p ps=0u w=540000u l=150000u
X7 Q a_1602_7# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X8 a_652_n19# SET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=1.134e+11p pd=1.38e+06u as=0p ps=0u w=420000u l=150000u
X9 a_586_7# a_193_7# a_476_7# VNB sky130_fd_pr__nfet_01v8 ad=1.341e+11p pd=1.5e+06u as=1.44e+11p ps=1.52e+06u w=360000u l=150000u
X10 VGND a_652_n19# a_586_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X11 Q a_1602_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X12 a_956_373# a_476_7# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=9.66e+10p pd=1.3e+06u as=0p ps=0u w=420000u l=150000u
X13 a_381_7# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.499e+11p pd=2.35e+06u as=0p ps=0u w=840000u l=150000u
X14 VPWR a_1032_373# a_1602_7# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X15 a_1140_373# a_193_7# a_1032_373# VPB sky130_fd_pr__pfet_01v8_hvt ad=8.82e+10p pd=1.26e+06u as=2.73e+11p ps=2.98e+06u w=420000u l=150000u
X16 a_1032_373# a_193_7# a_1056_7# VNB sky130_fd_pr__nfet_01v8 ad=1.386e+11p pd=1.5e+06u as=0p ps=0u w=420000u l=150000u
X17 a_1224_7# a_27_7# a_1032_373# VNB sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=0p ps=0u w=420000u l=150000u
X18 VPWR a_476_7# a_652_n19# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X19 a_1032_373# a_27_7# a_956_373# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X20 VPWR SET_B a_1032_373# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X21 a_1296_7# a_1182_221# a_1224_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X22 a_1182_221# a_1032_373# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.184e+11p pd=2.2e+06u as=0p ps=0u w=840000u l=150000u
X23 a_796_7# SET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=0p ps=0u w=420000u l=150000u
X24 a_193_7# a_27_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X25 VGND a_1032_373# a_1602_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X26 a_652_n19# a_476_7# a_796_7# VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X27 VPWR a_652_n19# a_562_373# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X28 VGND CLK a_27_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X29 a_476_7# a_27_7# a_381_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=360000u l=150000u
X30 a_476_7# a_193_7# a_381_7# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X31 VPWR a_1182_221# a_1140_373# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__decap_6 VGND VPWR VPB VNB
X0 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=2.86e+11p pd=3.24e+06u as=0p ps=0u w=550000u l=1.97e+06u
X1 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=4.524e+11p pd=4.52e+06u as=0p ps=0u w=870000u l=1.97e+06u
.ends

.subckt sky130_fd_sc_hd__a32o_1 VGND X B1 VPWR A1 B2 A2 A3 VPB VNB
X0 VGND a_93_n19# X VNB sky130_fd_pr__nfet_01v8 ad=5.07e+11p pd=4.16e+06u as=2.145e+11p ps=1.96e+06u w=650000u l=150000u
X1 VGND B2 a_584_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.365e+11p ps=1.72e+06u w=650000u l=150000u
X2 a_93_n19# A1 a_346_7# VNB sky130_fd_pr__nfet_01v8 ad=2.86e+11p pd=2.18e+06u as=2.925e+11p ps=2.2e+06u w=650000u l=150000u
X3 a_250_257# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=9.65e+11p pd=7.93e+06u as=9.35e+11p ps=5.87e+06u w=1e+06u l=150000u
X4 a_250_257# B2 a_93_n19# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.8e+11p ps=2.56e+06u w=1e+06u l=150000u
X5 VPWR a_93_n19# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=3.3e+11p ps=2.66e+06u w=1e+06u l=150000u
X6 a_93_n19# B1 a_250_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 a_250_257# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_256_7# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=1.95e+11p pd=1.9e+06u as=0p ps=0u w=650000u l=150000u
X9 a_346_7# A2 a_256_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 VPWR A2 a_250_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_584_7# B1 a_93_n19# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__dfrtp_1 RESET_B Q VGND CLK VPWR VPB VNB D
X0 a_1270_373# a_193_7# a_1108_7# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.134e+11p pd=1.38e+06u as=1.176e+11p ps=1.4e+06u w=420000u l=150000u
X1 Q a_1283_n19# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=1.0617e+12p ps=9.62e+06u w=650000u l=150000u
X2 a_1108_7# a_193_7# a_761_249# VNB sky130_fd_pr__nfet_01v8 ad=1.422e+11p pd=1.51e+06u as=1.998e+11p ps=1.97e+06u w=360000u l=150000u
X3 VPWR CLK a_27_7# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.2195e+12p pd=1.255e+07u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X4 a_448_7# D VGND VNB sky130_fd_pr__nfet_01v8 ad=1.32e+11p pd=1.49e+06u as=0p ps=0u w=420000u l=150000u
X5 a_761_249# a_543_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X6 a_1283_n19# a_1108_7# a_1462_7# VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=1.281e+11p ps=1.45e+06u w=420000u l=150000u
X7 a_193_7# a_27_7# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=1.664e+11p pd=1.8e+06u as=0p ps=0u w=640000u l=150000u
X8 Q a_1283_n19# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X9 a_543_7# a_193_7# a_448_7# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.449e+11p pd=1.53e+06u as=1.302e+11p ps=1.46e+06u w=420000u l=150000u
X10 a_1462_7# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X11 a_543_7# a_27_7# a_448_7# VNB sky130_fd_pr__nfet_01v8 ad=1.188e+11p pd=1.38e+06u as=0p ps=0u w=360000u l=150000u
X12 a_651_373# a_27_7# a_543_7# VPB sky130_fd_pr__pfet_01v8_hvt ad=3.402e+11p pd=3.3e+06u as=0p ps=0u w=420000u l=150000u
X13 a_651_373# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X14 VPWR a_1108_7# a_1283_n19# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X15 a_805_7# a_761_249# a_639_7# VNB sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=2.802e+11p ps=2.2e+06u w=420000u l=150000u
X16 a_193_7# a_27_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X17 a_448_7# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X18 a_639_7# a_193_7# a_543_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=360000u l=150000u
X19 VPWR a_761_249# a_651_373# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X20 a_1108_7# a_27_7# a_761_249# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.583e+11p ps=2.37e+06u w=420000u l=150000u
X21 VGND RESET_B a_805_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X22 a_1283_n19# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X23 VGND CLK a_27_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X24 a_1217_7# a_27_7# a_1108_7# VNB sky130_fd_pr__nfet_01v8 ad=1.338e+11p pd=1.5e+06u as=0p ps=0u w=360000u l=150000u
X25 VGND a_1283_n19# a_1217_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X26 a_761_249# a_543_7# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=840000u l=150000u
X27 VPWR a_1283_n19# a_1270_373# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__clkbuf_2 VGND X VPWR A VPB VNB
X0 VGND a_27_7# X VNB sky130_fd_pr__nfet_01v8 ad=2.457e+11p pd=2.85e+06u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X1 X a_27_7# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=5.85e+11p ps=5.17e+06u w=1e+06u l=150000u
X2 VGND A a_27_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.113e+11p ps=1.37e+06u w=420000u l=150000u
X3 VPWR A a_27_7# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.65e+11p ps=2.53e+06u w=1e+06u l=150000u
X4 X a_27_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X5 VPWR a_27_7# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__or2_2 VGND X VPWR A VPB B VNB
X0 VPWR A a_121_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=5.715e+11p pd=5.23e+06u as=8.82e+10p ps=1.26e+06u w=420000u l=150000u
X1 X a_39_257# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.755e+11p pd=1.84e+06u as=4.917e+11p ps=5.19e+06u w=650000u l=150000u
X2 a_121_257# B a_39_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X3 VPWR a_39_257# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X4 VGND a_39_257# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 X a_39_257# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 VGND A a_39_257# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X7 a_39_257# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__or2_1 VGND X VPWR A VPB B VNB
X0 VGND A a_68_257# VNB sky130_fd_pr__nfet_01v8 ad=3.097e+11p pd=3.33e+06u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X1 X a_68_257# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X2 X a_68_257# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=3.4e+11p pd=2.68e+06u as=2.915e+11p ps=2.67e+06u w=1e+06u l=150000u
X3 VPWR A a_150_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=8.82e+10p ps=1.26e+06u w=420000u l=150000u
X4 a_150_257# B a_68_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X5 a_68_257# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a21oi_1 VGND Y B1 VPWR A1 A2 VPB VNB
X0 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=1.82e+11p pd=1.86e+06u as=3.445e+11p ps=3.66e+06u w=650000u l=150000u
X1 VGND A2 a_199_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.9175e+11p ps=1.89e+06u w=650000u l=150000u
X2 VPWR A1 a_113_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=2.95e+11p pd=2.59e+06u as=5.45e+11p ps=5.09e+06u w=1e+06u l=150000u
X3 a_113_257# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.65e+11p ps=2.53e+06u w=1e+06u l=150000u
X4 a_113_257# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_199_7# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__mux2_1 S VGND X VPWR A0 A1 VPB VNB
X0 a_535_334# A1 a_76_159# VPB sky130_fd_pr__pfet_01v8_hvt ad=8.82e+10p pd=1.26e+06u as=3.864e+11p ps=2.68e+06u w=420000u l=150000u
X1 a_76_159# A0 a_218_334# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.533e+11p ps=1.57e+06u w=420000u l=150000u
X2 a_439_7# A0 a_76_159# VNB sky130_fd_pr__nfet_01v8 ad=1.386e+11p pd=1.5e+06u as=1.995e+11p ps=1.79e+06u w=420000u l=150000u
X3 VGND a_505_n19# a_439_7# VNB sky130_fd_pr__nfet_01v8 ad=5.155e+11p pd=4.31e+06u as=0p ps=0u w=420000u l=150000u
X4 VPWR a_76_159# X VPB sky130_fd_pr__pfet_01v8_hvt ad=4.553e+11p pd=4.29e+06u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X5 a_218_334# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X6 a_505_n19# S VGND VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X7 VPWR a_505_n19# a_535_334# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X8 a_505_n19# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=1.176e+11p pd=1.4e+06u as=0p ps=0u w=420000u l=150000u
X9 a_218_7# S VGND VNB sky130_fd_pr__nfet_01v8 ad=1.386e+11p pd=1.5e+06u as=0p ps=0u w=420000u l=150000u
X10 a_76_159# A1 a_218_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X11 VGND a_76_159# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__decap_12 VGND VPWR VPB VNB
X0 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=2.86e+11p pd=3.24e+06u as=0p ps=0u w=550000u l=4.73e+06u
X1 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=4.524e+11p pd=4.52e+06u as=0p ps=0u w=870000u l=4.73e+06u
.ends

.subckt sky130_fd_sc_hd__o21ba_1 B1_N VGND X VPWR A1 A2 VPB VNB
X0 a_448_7# a_222_53# a_79_159# VNB sky130_fd_pr__nfet_01v8 ad=3.8675e+11p pd=3.79e+06u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X1 VGND A2 a_448_7# VNB sky130_fd_pr__nfet_01v8 ad=3.76e+11p pd=3.81e+06u as=0p ps=0u w=650000u l=150000u
X2 VPWR a_79_159# X VPB sky130_fd_pr__pfet_01v8_hvt ad=9.515e+11p pd=7.99e+06u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X3 a_79_159# a_222_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=3.3e+11p pd=2.66e+06u as=0p ps=0u w=1e+06u l=150000u
X4 a_222_53# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X5 a_544_257# A2 a_79_159# VPB sky130_fd_pr__pfet_01v8_hvt ad=2.1e+11p pd=2.42e+06u as=0p ps=0u w=1e+06u l=150000u
X6 VGND a_79_159# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X7 a_222_53# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=1.176e+11p pd=1.4e+06u as=0p ps=0u w=420000u l=150000u
X8 a_448_7# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 VPWR A1 a_544_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__buf_8 VGND X VPWR A VPB VNB
X0 VGND a_27_7# X VNB sky130_fd_pr__nfet_01v8 ad=1.0465e+12p pd=1.102e+07u as=7.02e+11p ps=7.36e+06u w=650000u l=150000u
X1 VPWR A a_27_7# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.61e+12p pd=1.522e+07u as=5.3e+11p ps=5.06e+06u w=1e+06u l=150000u
X2 VPWR a_27_7# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.08e+12p ps=1.016e+07u w=1e+06u l=150000u
X3 VPWR A a_27_7# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_27_7# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 X a_27_7# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 VGND a_27_7# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 VPWR a_27_7# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 X a_27_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 VGND a_27_7# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 X a_27_7# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 X a_27_7# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 X a_27_7# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 X a_27_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 VPWR a_27_7# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 X a_27_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X16 VPWR a_27_7# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X17 a_27_7# A VGND VNB sky130_fd_pr__nfet_01v8 ad=3.445e+11p pd=3.66e+06u as=0p ps=0u w=650000u l=150000u
X18 X a_27_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X19 VGND A a_27_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X20 VGND A a_27_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X21 VGND a_27_7# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__dfrtp_4 RESET_B Q VGND CLK VPWR VPB VNB D
X0 a_1270_373# a_193_7# a_1108_7# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.134e+11p pd=1.38e+06u as=1.176e+11p ps=1.4e+06u w=420000u l=150000u
X1 a_1108_7# a_193_7# a_761_249# VNB sky130_fd_pr__nfet_01v8 ad=1.422e+11p pd=1.51e+06u as=1.998e+11p ps=1.97e+06u w=360000u l=150000u
X2 VGND a_1283_n19# Q VNB sky130_fd_pr__nfet_01v8 ad=1.3795e+12p pd=1.312e+07u as=3.51e+11p ps=3.68e+06u w=650000u l=150000u
X3 VPWR CLK a_27_7# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.7533e+12p pd=1.756e+07u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X4 a_448_7# D VGND VNB sky130_fd_pr__nfet_01v8 ad=1.32e+11p pd=1.49e+06u as=0p ps=0u w=420000u l=150000u
X5 a_761_249# a_543_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X6 a_1283_n19# a_1108_7# a_1462_7# VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=1.281e+11p ps=1.45e+06u w=420000u l=150000u
X7 a_193_7# a_27_7# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=1.664e+11p pd=1.8e+06u as=0p ps=0u w=640000u l=150000u
X8 VGND a_1283_n19# Q VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 a_543_7# a_193_7# a_448_7# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.449e+11p pd=1.53e+06u as=1.302e+11p ps=1.46e+06u w=420000u l=150000u
X10 a_1462_7# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X11 Q a_1283_n19# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 a_543_7# a_27_7# a_448_7# VNB sky130_fd_pr__nfet_01v8 ad=1.188e+11p pd=1.38e+06u as=0p ps=0u w=360000u l=150000u
X13 a_651_373# a_27_7# a_543_7# VPB sky130_fd_pr__pfet_01v8_hvt ad=3.402e+11p pd=3.3e+06u as=0p ps=0u w=420000u l=150000u
X14 a_651_373# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X15 Q a_1283_n19# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=5.4e+11p pd=5.08e+06u as=0p ps=0u w=1e+06u l=150000u
X16 Q a_1283_n19# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X17 VPWR a_1108_7# a_1283_n19# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X18 a_805_7# a_761_249# a_639_7# VNB sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=2.802e+11p ps=2.2e+06u w=420000u l=150000u
X19 a_193_7# a_27_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X20 a_448_7# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X21 a_639_7# a_193_7# a_543_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=360000u l=150000u
X22 VPWR a_761_249# a_651_373# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X23 a_1108_7# a_27_7# a_761_249# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.583e+11p ps=2.37e+06u w=420000u l=150000u
X24 VGND RESET_B a_805_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X25 a_1283_n19# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X26 VGND CLK a_27_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X27 Q a_1283_n19# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X28 a_1217_7# a_27_7# a_1108_7# VNB sky130_fd_pr__nfet_01v8 ad=1.338e+11p pd=1.5e+06u as=0p ps=0u w=360000u l=150000u
X29 VGND a_1283_n19# a_1217_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X30 a_761_249# a_543_7# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=840000u l=150000u
X31 VPWR a_1283_n19# a_1270_373# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X32 VPWR a_1283_n19# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X33 VPWR a_1283_n19# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__buf_1 VGND X VPWR A VPB VNB
X0 VPWR A a_27_7# VPB sky130_fd_pr__pfet_01v8_hvt ad=2.291e+11p pd=2.16e+06u as=2.054e+11p ps=2.1e+06u w=790000u l=150000u
X1 X a_27_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.352e+11p pd=1.56e+06u as=1.508e+11p ps=1.62e+06u w=520000u l=150000u
X2 X a_27_7# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.054e+11p pd=2.1e+06u as=0p ps=0u w=790000u l=150000u
X3 VGND A a_27_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.352e+11p ps=1.56e+06u w=520000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a31o_1 VGND X B1 VPWR A1 A2 A3 VPB VNB
X0 VPWR A2 a_209_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=6.75e+11p pd=5.35e+06u as=6.5e+11p ps=5.3e+06u w=1e+06u l=150000u
X1 VGND a_80_n19# X VNB sky130_fd_pr__nfet_01v8 ad=4.3225e+11p pd=3.93e+06u as=1.7225e+11p ps=1.83e+06u w=650000u l=150000u
X2 a_303_7# A2 a_209_7# VNB sky130_fd_pr__nfet_01v8 ad=2.145e+11p pd=1.96e+06u as=2.08e+11p ps=1.94e+06u w=650000u l=150000u
X3 a_209_257# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 VPWR a_80_n19# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.65e+11p ps=2.53e+06u w=1e+06u l=150000u
X5 a_80_n19# A1 a_303_7# VNB sky130_fd_pr__nfet_01v8 ad=2.145e+11p pd=1.96e+06u as=0p ps=0u w=650000u l=150000u
X6 VGND B1 a_80_n19# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 a_209_7# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 a_209_257# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 a_80_n19# B1 a_209_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=3.2e+11p pd=2.64e+06u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__dfrtp_2 RESET_B Q VGND CLK VPWR VPB VNB D
X0 a_1270_373# a_193_7# a_1108_7# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.134e+11p pd=1.38e+06u as=1.176e+11p ps=1.4e+06u w=420000u l=150000u
X1 VPWR a_1283_n19# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=1.4795e+12p pd=1.507e+07u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X2 Q a_1283_n19# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.755e+11p pd=1.84e+06u as=1.2307e+12p ps=1.144e+07u w=650000u l=150000u
X3 a_1108_7# a_193_7# a_761_249# VNB sky130_fd_pr__nfet_01v8 ad=1.422e+11p pd=1.51e+06u as=1.998e+11p ps=1.97e+06u w=360000u l=150000u
X4 VPWR CLK a_27_7# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X5 a_448_7# D VGND VNB sky130_fd_pr__nfet_01v8 ad=1.32e+11p pd=1.49e+06u as=0p ps=0u w=420000u l=150000u
X6 a_761_249# a_543_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X7 a_1283_n19# a_1108_7# a_1462_7# VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=1.281e+11p ps=1.45e+06u w=420000u l=150000u
X8 a_193_7# a_27_7# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=1.664e+11p pd=1.8e+06u as=0p ps=0u w=640000u l=150000u
X9 Q a_1283_n19# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 VGND a_1283_n19# Q VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 a_543_7# a_193_7# a_448_7# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.449e+11p pd=1.53e+06u as=1.302e+11p ps=1.46e+06u w=420000u l=150000u
X12 a_1462_7# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X13 a_543_7# a_27_7# a_448_7# VNB sky130_fd_pr__nfet_01v8 ad=1.188e+11p pd=1.38e+06u as=0p ps=0u w=360000u l=150000u
X14 a_651_373# a_27_7# a_543_7# VPB sky130_fd_pr__pfet_01v8_hvt ad=3.402e+11p pd=3.3e+06u as=0p ps=0u w=420000u l=150000u
X15 a_651_373# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X16 VPWR a_1108_7# a_1283_n19# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X17 a_805_7# a_761_249# a_639_7# VNB sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=2.802e+11p ps=2.2e+06u w=420000u l=150000u
X18 a_193_7# a_27_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X19 a_448_7# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X20 a_639_7# a_193_7# a_543_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=360000u l=150000u
X21 VPWR a_761_249# a_651_373# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X22 a_1108_7# a_27_7# a_761_249# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.583e+11p ps=2.37e+06u w=420000u l=150000u
X23 VGND RESET_B a_805_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X24 a_1283_n19# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X25 VGND CLK a_27_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X26 a_1217_7# a_27_7# a_1108_7# VNB sky130_fd_pr__nfet_01v8 ad=1.338e+11p pd=1.5e+06u as=0p ps=0u w=360000u l=150000u
X27 VGND a_1283_n19# a_1217_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X28 a_761_249# a_543_7# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=840000u l=150000u
X29 VPWR a_1283_n19# a_1270_373# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o21a_1 VGND X B1 VPWR A1 A2 VPB VNB
X0 a_297_7# B1 a_79_n19# VNB sky130_fd_pr__nfet_01v8 ad=3.705e+11p pd=3.74e+06u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X1 VPWR A1 a_382_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=9.15e+11p pd=5.83e+06u as=3.05e+11p ps=2.61e+06u w=1e+06u l=150000u
X2 VPWR a_79_n19# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.8e+11p ps=2.56e+06u w=1e+06u l=150000u
X3 a_297_7# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=3.445e+11p ps=3.66e+06u w=650000u l=150000u
X4 a_382_257# A2 a_79_n19# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=3.9e+11p ps=2.78e+06u w=1e+06u l=150000u
X5 VGND a_79_n19# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X6 VGND A2 a_297_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 a_79_n19# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__or3_2 VGND X VPWR A VPB B VNB C
X0 VGND a_30_13# X VNB sky130_fd_pr__nfet_01v8 ad=5.024e+11p pd=5.23e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X1 VGND A a_30_13# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=2.226e+11p ps=2.74e+06u w=420000u l=150000u
X2 X a_30_13# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=6.115e+11p ps=5.31e+06u w=1e+06u l=150000u
X3 X a_30_13# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_184_257# B a_112_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.386e+11p pd=1.5e+06u as=8.82e+10p ps=1.26e+06u w=420000u l=150000u
X5 VPWR A a_184_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X6 VPWR a_30_13# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 VGND C a_30_13# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X8 a_112_257# C a_30_13# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X9 a_30_13# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__decap_3 VGND VPWR VPB VNB
X0 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=2.86e+11p pd=3.24e+06u as=0p ps=0u w=550000u l=590000u
X1 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=4.524e+11p pd=4.52e+06u as=0p ps=0u w=870000u l=590000u
.ends

.subckt sky130_fd_sc_hd__nor2_1 VGND Y VPWR A VPB B VNB
X0 a_109_257# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=2.1e+11p pd=2.42e+06u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X1 VPWR A a_109_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X2 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=3.38e+11p pd=3.64e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X3 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a2bb2oi_1 VGND A2_N Y B1 VPWR B2 VPB VNB A1_N
X0 VPWR B2 a_397_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=5.3e+11p pd=5.06e+06u as=5.3e+11p ps=5.06e+06u w=1e+06u l=150000u
X1 a_481_7# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=1.755e+11p pd=1.84e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X2 Y a_109_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=9.035e+11p ps=6.68e+06u w=650000u l=150000u
X3 a_109_257# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.1e+11p pd=2.42e+06u as=0p ps=0u w=1e+06u l=150000u
X4 VGND B1 a_481_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 a_109_7# A2_N a_109_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X6 VGND A2_N a_109_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X7 a_109_7# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 a_397_257# a_109_7# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=3.4e+11p ps=2.68e+06u w=1e+06u l=150000u
X9 a_397_257# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__clkbuf_1 VGND X VPWR A VPB VNB
X0 VPWR a_75_172# X VPB sky130_fd_pr__pfet_01v8_hvt ad=2.291e+11p pd=2.16e+06u as=2.054e+11p ps=2.1e+06u w=790000u l=150000u
X1 a_75_172# A VGND VNB sky130_fd_pr__nfet_01v8 ad=1.352e+11p pd=1.56e+06u as=1.508e+11p ps=1.62e+06u w=520000u l=150000u
X2 a_75_172# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.054e+11p pd=2.1e+06u as=0p ps=0u w=790000u l=150000u
X3 VGND a_75_172# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.352e+11p ps=1.56e+06u w=520000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a22o_1 VGND X B1 VPWR B2 A1 A2 VPB VNB
X0 a_109_257# B2 a_27_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=5.9e+11p pd=5.18e+06u as=5.1285e+11p ps=5.04e+06u w=1e+06u l=150000u
X1 a_27_257# B1 a_109_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 X a_27_257# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=3.705e+11p ps=3.74e+06u w=650000u l=150000u
X3 VPWR A2 a_109_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=5.629e+11p pd=5.14e+06u as=0p ps=0u w=1e+06u l=150000u
X4 a_27_257# B1 a_109_7# VNB sky130_fd_pr__nfet_01v8 ad=3.38e+11p pd=3.64e+06u as=1.495e+11p ps=1.76e+06u w=650000u l=150000u
X5 a_109_257# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 VGND A2 a_373_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=2.275e+11p ps=2e+06u w=650000u l=150000u
X7 a_109_7# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 X a_27_257# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X9 a_373_7# A1 a_27_257# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__clkbuf_16 VGND X VPWR A VPB VNB
X0 VPWR a_110_7# X VPB sky130_fd_pr__pfet_01v8_hvt ad=3.045e+12p pd=2.809e+07u as=2.24e+12p ps=2.048e+07u w=1e+06u l=150000u
X1 X a_110_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=9.408e+11p pd=1.12e+07u as=1.2789e+12p ps=1.533e+07u w=420000u l=150000u
X2 VGND a_110_7# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 VPWR a_110_7# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 X a_110_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X5 VPWR a_110_7# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_110_7# A VGND VNB sky130_fd_pr__nfet_01v8 ad=2.352e+11p pd=2.8e+06u as=0p ps=0u w=420000u l=150000u
X7 VGND a_110_7# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X8 VGND a_110_7# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X9 X a_110_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X10 X a_110_7# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_110_7# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X12 X a_110_7# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 VGND a_110_7# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X14 X a_110_7# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 VPWR A a_110_7# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=5.6e+11p ps=5.12e+06u w=1e+06u l=150000u
X16 VGND a_110_7# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X17 X a_110_7# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X18 VPWR a_110_7# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X19 VGND a_110_7# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X20 a_110_7# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X21 VGND a_110_7# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X22 VPWR A a_110_7# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X23 X a_110_7# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X24 a_110_7# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X25 VGND a_110_7# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X26 VPWR a_110_7# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X27 X a_110_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X28 VPWR a_110_7# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X29 VGND A a_110_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X30 X a_110_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X31 X a_110_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X32 X a_110_7# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X33 VGND A a_110_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X34 X a_110_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X35 VPWR a_110_7# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X36 X a_110_7# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X37 X a_110_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X38 VPWR a_110_7# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X39 X a_110_7# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__o221ai_4 VGND Y C1 B1 VPWR B2 A1 A2 VPB VNB
X0 a_553_257# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=1.08e+12p pd=1.016e+07u as=2.525e+12p ps=1.905e+07u w=1e+06u l=150000u
X1 a_471_7# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=1.6185e+12p pd=1.668e+07u as=7.02e+11p ps=7.36e+06u w=650000u l=150000u
X2 a_553_257# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.62e+12p ps=1.524e+07u w=1e+06u l=150000u
X3 a_27_7# B1 a_471_7# VNB sky130_fd_pr__nfet_01v8 ad=1.2285e+12p pd=1.288e+07u as=0p ps=0u w=650000u l=150000u
X4 a_471_7# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 VPWR A1 a_1241_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.08e+12p ps=1.016e+07u w=1e+06u l=150000u
X6 a_471_7# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 VPWR B1 a_553_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 VGND A2 a_471_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 a_553_257# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 Y C1 a_27_7# VNB sky130_fd_pr__nfet_01v8 ad=3.51e+11p pd=3.68e+06u as=0p ps=0u w=650000u l=150000u
X11 a_471_7# B1 a_27_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 VGND A2 a_471_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 Y C1 a_27_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 Y B2 a_553_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X16 VGND A1 a_471_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X17 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X18 a_1241_257# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X19 a_27_7# B1 a_471_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X20 Y B2 a_553_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X21 a_27_7# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X22 a_553_257# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X23 VGND A1 a_471_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X24 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X25 a_27_7# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X26 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X27 a_471_7# B2 a_27_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X28 a_1241_257# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X29 a_1241_257# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X30 a_471_7# B1 a_27_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X31 a_1241_257# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X32 a_471_7# B2 a_27_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X33 Y A2 a_1241_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X34 Y A2 a_1241_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X35 a_27_7# B2 a_471_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X36 VPWR B1 a_553_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X37 VPWR A1 a_1241_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X38 a_27_7# B2 a_471_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X39 a_471_7# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o21ai_1 VGND Y B1 VPWR A1 A2 VPB VNB
X0 Y B1 a_27_7# VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=3.445e+11p ps=3.66e+06u w=650000u l=150000u
X1 a_109_257# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.1e+11p pd=2.42e+06u as=4.42e+11p ps=4.44e+06u w=1e+06u l=150000u
X2 Y A2 a_109_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=3.48e+11p pd=2.78e+06u as=0p ps=0u w=1e+06u l=150000u
X3 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=700000u l=150000u
X4 a_27_7# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=2.145e+11p ps=1.96e+06u w=650000u l=150000u
X5 VGND A1 a_27_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__mux2_2 S VGND X A0 VPWR A1 VPB VNB
X0 a_578_7# A1 a_79_n19# VNB sky130_fd_pr__nfet_01v8 ad=1.155e+11p pd=1.39e+06u as=3.465e+11p ps=2.49e+06u w=420000u l=150000u
X1 X a_79_n19# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=7.884e+11p ps=7.17e+06u w=1e+06u l=150000u
X2 a_306_329# a_257_159# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=4.576e+11p pd=2.71e+06u as=0p ps=0u w=640000u l=150000u
X3 VPWR a_79_n19# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_288_7# a_257_159# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.365e+11p pd=1.49e+06u as=4.764e+11p ps=5.15e+06u w=420000u l=150000u
X5 a_79_n19# A1 a_306_329# VPB sky130_fd_pr__pfet_01v8_hvt ad=2.624e+11p pd=2.1e+06u as=0p ps=0u w=640000u l=150000u
X6 a_79_n19# A0 a_288_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X7 VGND S a_578_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X8 a_257_159# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=1.728e+11p pd=1.82e+06u as=0p ps=0u w=640000u l=150000u
X9 VGND a_79_n19# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X10 a_591_329# A0 a_79_n19# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.344e+11p pd=1.7e+06u as=0p ps=0u w=640000u l=150000u
X11 VPWR S a_591_329# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X12 X a_79_n19# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 a_257_159# S VGND VNB sky130_fd_pr__nfet_01v8 ad=1.134e+11p pd=1.38e+06u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o211a_1 VGND X B1 C1 VPWR A1 A2 VPB VNB
X0 VPWR a_79_n19# X VPB sky130_fd_pr__pfet_01v8_hvt ad=8.7e+11p pd=7.74e+06u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X1 a_79_n19# C1 a_510_7# VNB sky130_fd_pr__nfet_01v8 ad=1.95e+11p pd=1.9e+06u as=2.275e+11p ps=2e+06u w=650000u l=150000u
X2 VPWR B1 a_79_n19# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=7.4e+11p ps=5.48e+06u w=1e+06u l=150000u
X3 VGND A1 a_215_7# VNB sky130_fd_pr__nfet_01v8 ad=3.8025e+11p pd=3.77e+06u as=4.55e+11p ps=4e+06u w=650000u l=150000u
X4 a_510_7# B1 a_215_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 a_79_n19# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_79_n19# A2 a_297_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=3.25e+11p ps=2.65e+06u w=1e+06u l=150000u
X7 a_215_7# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 a_297_257# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 VGND a_79_n19# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o22a_1 VGND X B1 VPWR B2 A1 A2 VPB VNB
X0 VGND A2 a_215_7# VNB sky130_fd_pr__nfet_01v8 ad=3.445e+11p pd=3.66e+06u as=5.655e+11p ps=5.64e+06u w=650000u l=150000u
X1 a_215_7# B2 a_78_159# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X2 a_215_7# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 a_78_159# B1 a_215_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_292_257# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.35e+11p pd=2.47e+06u as=1.005e+12p ps=6.01e+06u w=1e+06u l=150000u
X5 VPWR a_78_159# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.8e+11p ps=2.56e+06u w=1e+06u l=150000u
X6 a_78_159# B2 a_292_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=4.7e+11p pd=2.94e+06u as=0p ps=0u w=1e+06u l=150000u
X7 VGND a_78_159# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X8 a_493_257# A2 a_78_159# VPB sky130_fd_pr__pfet_01v8_hvt ad=2.1e+11p pd=2.42e+06u as=0p ps=0u w=1e+06u l=150000u
X9 VPWR A1 a_493_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__o32a_1 VGND X B1 VPWR A1 B2 A2 A3 VPB VNB
X0 a_77_159# A3 a_323_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=3.9e+11p pd=2.78e+06u as=3.9e+11p ps=2.78e+06u w=1e+06u l=150000u
X1 VPWR B1 a_539_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=5.6e+11p pd=5.12e+06u as=4.1e+11p ps=2.82e+06u w=1e+06u l=150000u
X2 VGND a_77_159# X VNB sky130_fd_pr__nfet_01v8 ad=4.29e+11p pd=3.92e+06u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X3 VPWR a_77_159# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=3.35e+11p ps=2.67e+06u w=1e+06u l=150000u
X4 a_227_7# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=6.565e+11p pd=5.92e+06u as=0p ps=0u w=650000u l=150000u
X5 a_227_7# B1 a_77_159# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=2.665e+11p ps=2.12e+06u w=650000u l=150000u
X6 a_227_7# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 VGND A2 a_227_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 a_227_257# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=3.3e+11p pd=2.66e+06u as=0p ps=0u w=1e+06u l=150000u
X9 a_323_257# A2 a_227_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 a_539_257# B2 a_77_159# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_77_159# B2 a_227_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__or3_1 VGND X VPWR A VPB B VNB C
X0 VPWR A a_183_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=2.965e+11p pd=2.68e+06u as=1.386e+11p ps=1.5e+06u w=420000u l=150000u
X1 X a_29_13# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.8e+11p pd=2.56e+06u as=0p ps=0u w=1e+06u l=150000u
X2 a_183_257# B a_111_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=8.82e+10p ps=1.26e+06u w=420000u l=150000u
X3 a_111_257# C a_29_13# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X4 X a_29_13# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.82e+11p pd=1.86e+06u as=3.1715e+11p ps=3.36e+06u w=650000u l=150000u
X5 VGND C a_29_13# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=2.226e+11p ps=2.74e+06u w=420000u l=150000u
X6 VGND A a_29_13# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X7 a_29_13# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o221a_1 VGND X C1 B1 VPWR B2 A1 A2 VPB VNB
X0 VGND A1 a_240_7# VNB sky130_fd_pr__nfet_01v8 ad=3.445e+11p pd=3.66e+06u as=3.51e+11p ps=3.68e+06u w=650000u l=150000u
X1 a_51_257# B2 a_245_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.165e+12p pd=6.33e+06u as=2.1e+11p ps=2.42e+06u w=1e+06u l=150000u
X2 a_149_7# B2 a_240_7# VNB sky130_fd_pr__nfet_01v8 ad=3.6725e+11p pd=3.73e+06u as=0p ps=0u w=650000u l=150000u
X3 a_512_257# A2 a_51_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=2.1e+11p pd=2.42e+06u as=0p ps=0u w=1e+06u l=150000u
X4 VPWR A1 a_512_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=6.6e+11p pd=5.32e+06u as=0p ps=0u w=1e+06u l=150000u
X5 a_149_7# C1 a_51_257# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=2.015e+11p ps=1.92e+06u w=650000u l=150000u
X6 X a_51_257# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.8e+11p pd=2.56e+06u as=0p ps=0u w=1e+06u l=150000u
X7 VPWR C1 a_51_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_245_257# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 a_240_7# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 a_240_7# B1 a_149_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 X a_51_257# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.82e+11p pd=1.86e+06u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__and3_2 VGND X VPWR A VPB B VNB C
X0 VPWR A a_29_271# VPB sky130_fd_pr__pfet_01v8_hvt ad=6.749e+11p pd=6.59e+06u as=2.5795e+11p ps=2.99e+06u w=420000u l=150000u
X1 X a_29_271# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=0p ps=0u w=1e+06u l=150000u
X2 VGND C a_184_13# VNB sky130_fd_pr__nfet_01v8 ad=4.3955e+11p pd=4.06e+06u as=1.071e+11p ps=1.35e+06u w=420000u l=150000u
X3 VPWR C a_29_271# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X4 VPWR a_29_271# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_184_13# B a_112_13# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=8.82e+10p ps=1.26e+06u w=420000u l=150000u
X6 a_112_13# A a_29_271# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X7 VGND a_29_271# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X8 X a_29_271# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 a_29_271# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a221oi_2 VGND Y C1 B1 VPWR B2 A1 A2 VPB VNB
X0 VPWR A2 a_301_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=5.4e+11p pd=5.08e+06u as=1.435e+12p ps=1.287e+07u w=1e+06u l=150000u
X1 a_735_7# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=3.51e+11p pd=3.68e+06u as=5.265e+11p ps=5.52e+06u w=650000u l=150000u
X2 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=1.0855e+12p pd=8.54e+06u as=0p ps=0u w=650000u l=150000u
X3 Y A1 a_735_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_27_257# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=1.07e+12p pd=1.014e+07u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X5 VGND A2 a_735_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_301_257# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 a_301_257# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 Y C1 a_27_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 VPWR A1 a_301_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 a_383_7# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=3.51e+11p pd=3.68e+06u as=0p ps=0u w=650000u l=150000u
X11 a_383_7# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 a_735_7# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 a_301_257# B1 a_27_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 a_301_257# B2 a_27_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 Y B1 a_383_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X16 a_27_257# B2 a_301_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X17 a_27_257# B1 a_301_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X18 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X19 VGND B2 a_383_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o2111a_1 VGND X D1 C1 B1 VPWR A1 A2 VPB VNB
X0 VPWR a_79_n19# X VPB sky130_fd_pr__pfet_01v8_hvt ad=1.64e+12p pd=9.28e+06u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X1 a_409_7# C1 a_306_7# VNB sky130_fd_pr__nfet_01v8 ad=2.3725e+11p pd=2.03e+06u as=2.3725e+11p ps=2.03e+06u w=650000u l=150000u
X2 a_306_7# D1 a_79_n19# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.9825e+11p ps=1.91e+06u w=650000u l=150000u
X3 VGND A2 a_512_7# VNB sky130_fd_pr__nfet_01v8 ad=3.445e+11p pd=3.66e+06u as=5.6875e+11p ps=4.35e+06u w=650000u l=150000u
X4 a_79_n19# D1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=8.6e+11p pd=5.72e+06u as=0p ps=0u w=1e+06u l=150000u
X5 a_512_7# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_79_n19# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 VPWR C1 a_79_n19# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 VGND a_79_n19# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X9 a_512_7# B1 a_409_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 a_676_257# A2 a_79_n19# VPB sky130_fd_pr__pfet_01v8_hvt ad=2.1e+11p pd=2.42e+06u as=0p ps=0u w=1e+06u l=150000u
X11 VPWR A1 a_676_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__nand2_1 VGND Y VPWR A VPB B VNB
X0 a_113_7# B VGND VNB sky130_fd_pr__nfet_01v8 ad=1.755e+11p pd=1.84e+06u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X1 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=5.2e+11p pd=5.04e+06u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X2 Y A a_113_7# VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__and3_1 VGND X VPWR A VPB B VNB C
X0 VPWR A a_27_7# VPB sky130_fd_pr__pfet_01v8_hvt ad=3.9785e+11p pd=4.05e+06u as=2.415e+11p ps=2.83e+06u w=420000u l=150000u
X1 a_27_7# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 X a_27_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=2.633e+11p ps=2.28e+06u w=650000u l=150000u
X3 a_181_7# B a_109_7# VNB sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=8.82e+10p ps=1.26e+06u w=420000u l=150000u
X4 VGND C a_181_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X5 VPWR C a_27_7# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X6 X a_27_7# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X7 a_109_7# A a_27_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o22ai_1 VGND Y B1 VPWR B2 A1 A2 VPB VNB
X0 a_109_257# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.25e+11p pd=2.45e+06u as=5.3e+11p ps=5.06e+06u w=1e+06u l=150000u
X1 a_27_7# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=5.6875e+11p pd=5.65e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X2 VGND A2 a_27_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 a_307_257# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=2.1e+11p pd=2.42e+06u as=4.65e+11p ps=2.93e+06u w=1e+06u l=150000u
X4 VPWR A1 a_307_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 Y B2 a_109_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_27_7# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.8525e+11p ps=1.87e+06u w=650000u l=150000u
X7 Y B1 a_27_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__or3_4 VGND X VPWR A VPB B VNB C
X0 VPWR A a_193_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.43e+12p pd=8.86e+06u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X1 a_109_257# C a_27_7# VPB sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X2 VPWR a_27_7# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=5.4e+11p ps=5.08e+06u w=1e+06u l=150000u
X3 a_193_257# B a_109_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 VGND a_27_7# X VNB sky130_fd_pr__nfet_01v8 ad=1.07575e+12p pd=8.51e+06u as=3.51e+11p ps=3.68e+06u w=650000u l=150000u
X5 a_27_7# B VGND VNB sky130_fd_pr__nfet_01v8 ad=3.445e+11p pd=3.66e+06u as=0p ps=0u w=650000u l=150000u
X6 VGND a_27_7# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 X a_27_7# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 X a_27_7# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 VGND C a_27_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 X a_27_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 VGND A a_27_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 VPWR a_27_7# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 X a_27_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a2bb2o_1 VGND A2_N X B1 VPWR B2 VPB VNB A1_N
X0 a_76_159# a_226_7# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.134e+11p pd=1.38e+06u as=6.266e+11p ps=5.69e+06u w=420000u l=150000u
X1 VGND B1 a_556_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X2 VPWR a_76_159# X VPB sky130_fd_pr__pfet_01v8_hvt ad=4.469e+11p pd=4.25e+06u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X3 a_556_7# B2 a_76_159# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X4 a_226_257# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=8.82e+10p pd=1.26e+06u as=0p ps=0u w=420000u l=150000u
X5 a_226_7# A2_N a_226_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.113e+11p pd=1.37e+06u as=0p ps=0u w=420000u l=150000u
X6 a_489_373# a_226_7# a_76_159# VPB sky130_fd_pr__pfet_01v8_hvt ad=2.226e+11p pd=2.74e+06u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X7 a_489_373# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X8 VGND A2_N a_226_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X9 VGND a_76_159# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X10 VPWR B2 a_489_373# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X11 a_226_7# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nor2_2 VGND Y VPWR A VPB B VNB
X0 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=3.51e+11p pd=3.68e+06u as=5.265e+11p ps=5.52e+06u w=650000u l=150000u
X1 a_27_257# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=8.1e+11p pd=7.62e+06u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X2 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 a_27_257# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 Y B a_27_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 VPWR A a_27_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__and2_1 VGND X VPWR A VPB B VNB
X0 X a_59_35# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=4.75e+11p pd=2.95e+06u as=4.507e+11p ps=4.18e+06u w=1e+06u l=150000u
X1 a_145_35# A a_59_35# VNB sky130_fd_pr__nfet_01v8 ad=1.134e+11p pd=1.38e+06u as=1.176e+11p ps=1.4e+06u w=420000u l=150000u
X2 a_59_35# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=1.134e+11p pd=1.38e+06u as=0p ps=0u w=420000u l=150000u
X3 VGND B a_145_35# VNB sky130_fd_pr__nfet_01v8 ad=2.236e+11p pd=2.08e+06u as=0p ps=0u w=420000u l=150000u
X4 VPWR B a_59_35# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X5 X a_59_35# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.82e+11p pd=1.86e+06u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__or4b_4 VGND X D_N VPWR A VPB B VNB C
X0 VGND C a_215_257# VNB sky130_fd_pr__nfet_01v8 ad=1.0513e+12p pd=1.077e+07u as=4.225e+11p ps=3.9e+06u w=650000u l=150000u
X1 X a_215_257# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=5.4e+11p pd=5.08e+06u as=1.0192e+12p ps=9.18e+06u w=1e+06u l=150000u
X2 VGND a_215_257# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=3.51e+11p ps=3.68e+06u w=650000u l=150000u
X3 VGND A a_215_257# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 VPWR a_215_257# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 X a_215_257# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_215_257# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 X a_215_257# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 a_487_257# B a_403_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X9 a_215_257# a_109_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 VPWR a_215_257# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_403_257# C a_297_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=3.8e+11p ps=2.76e+06u w=1e+06u l=150000u
X12 a_109_53# D_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X13 VPWR A a_487_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 a_109_53# D_N VGND VNB sky130_fd_pr__nfet_01v8 ad=1.0785e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X15 a_297_257# a_109_53# a_215_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X16 VGND a_215_257# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X17 X a_215_257# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__a31oi_2 VGND Y B1 VPWR A1 A2 A3 VPB VNB
X0 a_27_257# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=1.42e+12p pd=1.284e+07u as=1.36e+12p ps=8.72e+06u w=1e+06u l=150000u
X1 VPWR A2 a_27_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 VPWR A1 a_27_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 VPWR A3 a_27_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_27_257# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_27_257# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=5.72e+11p pd=5.66e+06u as=4.03e+11p ps=3.84e+06u w=650000u l=150000u
X7 Y B1 a_27_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=3.5e+11p pd=2.7e+06u as=0p ps=0u w=1e+06u l=150000u
X8 a_277_7# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=3.705e+11p pd=3.74e+06u as=0p ps=0u w=650000u l=150000u
X9 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 a_27_7# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=5.135e+11p pd=5.48e+06u as=0p ps=0u w=650000u l=150000u
X11 Y A1 a_277_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 a_27_7# A2 a_277_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 a_27_257# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 VGND A3 a_27_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 a_277_7# A2 a_27_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o221ai_1 VGND Y C1 B1 VPWR B2 A1 A2 VPB VNB
X0 VGND A2 a_213_83# VNB sky130_fd_pr__nfet_01v8 ad=1.755e+11p pd=1.84e+06u as=5.682e+11p ps=5.66e+06u w=650000u l=150000u
X1 Y B2 a_295_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=7.3e+11p pd=5.46e+06u as=2.4e+11p ps=2.48e+06u w=1e+06u l=150000u
X2 a_213_83# B2 a_109_7# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=3.409e+11p ps=3.66e+06u w=650000u l=150000u
X3 a_213_83# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_295_257# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.02e+12p ps=6.04e+06u w=1e+06u l=150000u
X5 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_109_7# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X7 a_493_257# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=2.1e+11p pd=2.42e+06u as=0p ps=0u w=1e+06u l=150000u
X8 VPWR A1 a_493_257# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 a_109_7# B1 a_213_83# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sarlogic ctln[0] ctln[1] ctln[2] ctln[3] ctln[4] ctln[5] ctln[6] ctln[7] ctlp[0]
+ ctlp[1] ctlp[2] ctlp[3] ctlp[4] ctlp[5] ctlp[6] ctlp[7] cal clk clkc comp en result[0]
+ result[1] result[2] result[3] result[4] result[5] result[6] result[7] rstn sample
+ trim[0] trim[1] trim[2] trim[3] trim[4] trimb[0] trimb[1] trimb[2] trimb[3] trimb[4]
+ valid VPWR VGND
XFILLER_13_111 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_13_144 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_13_155 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_294_ VGND _294_/Y VPWR _294_/A VPWR VGND sky130_fd_sc_hd__inv_2
X_346_ _346_/Q VGND _346_/SET_B _297_/B VPWR VPWR VGND _346_/D sky130_fd_sc_hd__dfstp_1
X_277_ VGND _277_/Y VPWR _277_/A VPWR VGND sky130_fd_sc_hd__inv_2
XFILLER_5_162 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
X_200_ VGND _337_/D _337_/Q VPWR _338_/Q _194_/X _197_/X _193_/Y VPWR VGND sky130_fd_sc_hd__a32o_1
X_329_ _346_/SET_B _329_/Q VGND _331_/CLK VPWR VPWR VGND _329_/D sky130_fd_sc_hd__dfrtp_1
XFILLER_2_110 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_0_68 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_0_13 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_18_53 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_15_87 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_16_142 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
Xoutput20 VGND ctlp[6] VPWR _281_/A VPWR VGND sky130_fd_sc_hd__clkbuf_2
Xoutput31 VGND trim[0] VPWR _285_/A VPWR VGND sky130_fd_sc_hd__clkbuf_2
Xoutput7 VGND ctln[1] VPWR _271_/Y VPWR VGND sky130_fd_sc_hd__clkbuf_2
XFILLER_22_156 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_293_ VGND _294_/A VPWR _340_/Q VPWR _313_/Q VGND sky130_fd_sc_hd__or2_2
XFILLER_9_138 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_3_46 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_12_77 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_10_115 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_10_126 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_276_ VGND _277_/A VPWR _328_/Q VPWR _319_/Q VGND sky130_fd_sc_hd__or2_1
X_345_ _345_/Q VGND _346_/SET_B _297_/B VPWR VPWR VGND _345_/D sky130_fd_sc_hd__dfstp_1
XFILLER_9_78 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
X_328_ _346_/SET_B _328_/Q VGND _297_/B VPWR VPWR VGND _328_/D sky130_fd_sc_hd__dfrtp_1
XFILLER_2_122 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_259_ VGND _261_/A _312_/Q VPWR _339_/Q _258_/S VPWR VGND sky130_fd_sc_hd__a21oi_1
XFILLER_0_25 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_9_67 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_20_11 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XFILLER_15_11 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_16_110 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_16_154 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
Xoutput21 VGND ctlp[7] VPWR _283_/A VPWR VGND sky130_fd_sc_hd__clkbuf_2
Xoutput10 VGND ctln[4] VPWR _277_/Y VPWR VGND sky130_fd_sc_hd__clkbuf_2
Xoutput8 VGND ctln[2] VPWR _273_/Y VPWR VGND sky130_fd_sc_hd__clkbuf_2
Xoutput32 VGND trim[1] VPWR _288_/A VPWR VGND sky130_fd_sc_hd__clkbuf_2
XFILLER_22_146 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
X_292_ VGND _292_/Y VPWR _292_/A VPWR VGND sky130_fd_sc_hd__inv_2
XFILLER_3_25 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_12_34 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_6_109 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_275_ VGND _275_/Y VPWR _275_/A VPWR VGND sky130_fd_sc_hd__inv_2
X_344_ _344_/Q VGND _346_/SET_B _297_/B VPWR VPWR VGND _344_/D sky130_fd_sc_hd__dfstp_1
XFILLER_5_131 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_0_59 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_3_3 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_327_ _346_/SET_B _327_/Q VGND _331_/CLK VPWR VPWR VGND _327_/D sky130_fd_sc_hd__dfrtp_1
X_258_ _258_/S VGND _313_/D VPWR _313_/Q _306_/X VPWR VGND sky130_fd_sc_hd__mux2_1
X_189_ VGND _190_/A VPWR _196_/A VPWR VGND sky130_fd_sc_hd__clkbuf_2
XFILLER_6_58 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
Xoutput22 VGND result[0] VPWR _315_/Q VPWR VGND sky130_fd_sc_hd__clkbuf_2
XFILLER_15_23 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
Xoutput33 VGND trim[2] VPWR _290_/A VPWR VGND sky130_fd_sc_hd__clkbuf_2
Xoutput9 VGND ctln[3] VPWR _275_/Y VPWR VGND sky130_fd_sc_hd__clkbuf_2
Xoutput11 VGND ctln[5] VPWR _279_/Y VPWR VGND sky130_fd_sc_hd__clkbuf_2
XFILLER_22_125 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_12
X_291_ VGND _292_/A VPWR _339_/Q VPWR _312_/Q VGND sky130_fd_sc_hd__or2_2
XFILLER_12_24 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
X_274_ VGND _275_/A VPWR _327_/Q VPWR _318_/Q VGND sky130_fd_sc_hd__or2_2
XFILLER_5_154 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_343_ repeater43/X _343_/Q VGND _343_/CLK VPWR VPWR VGND _343_/D sky130_fd_sc_hd__dfrtp_1
X_326_ repeater43/X _326_/Q VGND _331_/CLK VPWR VPWR VGND _326_/D sky130_fd_sc_hd__dfrtp_1
X_257_ _260_/B VGND _258_/S VPWR _190_/A _254_/Y VPWR VGND sky130_fd_sc_hd__o21ba_1
XFILLER_9_25 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_188_ _188_/S VGND _341_/D VPWR _307_/X _255_/B VPWR VGND sky130_fd_sc_hd__mux2_1
XFILLER_18_45 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_309_ _346_/SET_B _309_/Q VGND _340_/CLK VPWR VPWR VGND _309_/D sky130_fd_sc_hd__dfrtp_1
XFILLER_19_164 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
Xoutput23 VGND result[1] VPWR _316_/Q VPWR VGND sky130_fd_sc_hd__clkbuf_2
Xoutput34 VGND trim[3] VPWR _292_/A VPWR VGND sky130_fd_sc_hd__clkbuf_2
Xoutput12 VGND ctln[6] VPWR _281_/Y VPWR VGND sky130_fd_sc_hd__clkbuf_2
XFILLER_11_3 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_290_ VGND _290_/Y VPWR _290_/A VPWR VGND sky130_fd_sc_hd__inv_2
Xrepeater42 VGND _346_/SET_B VPWR repeater43/X VPWR VGND sky130_fd_sc_hd__buf_8
XFILLER_9_119 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
X_273_ VGND _273_/Y VPWR _273_/A VPWR VGND sky130_fd_sc_hd__inv_2
XFILLER_5_144 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_5_122 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
X_342_ repeater43/X _342_/Q VGND _343_/CLK VPWR VPWR VGND _342_/D sky130_fd_sc_hd__dfrtp_4
XFILLER_12_58 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_12_47 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_12_69 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_187_ VGND _255_/B VPWR _341_/Q VPWR VGND sky130_fd_sc_hd__buf_1
X_325_ repeater43/X _325_/Q VGND _331_/CLK VPWR VPWR VGND _325_/D sky130_fd_sc_hd__dfrtp_1
X_256_ VGND _260_/B _192_/B VPWR _196_/A _191_/B _255_/X VPWR VGND sky130_fd_sc_hd__a31o_1
X_239_ VGND _240_/B _319_/Q VPWR _328_/Q _232_/X VPWR VGND sky130_fd_sc_hd__a21oi_1
X_308_ _308_/S VGND _308_/X VPWR _192_/B _227_/A VPWR VGND sky130_fd_sc_hd__mux2_1
XFILLER_20_58 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_10_91 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
Xoutput24 VGND result[2] VPWR _317_/Q VPWR VGND sky130_fd_sc_hd__clkbuf_2
Xoutput35 VGND trim[4] VPWR _294_/A VPWR VGND sky130_fd_sc_hd__clkbuf_2
Xoutput13 VGND ctln[7] VPWR _283_/Y VPWR VGND sky130_fd_sc_hd__clkbuf_2
XFILLER_16_135 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_13_127 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_8_164 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
Xrepeater43 VGND repeater43/X VPWR input4/X VPWR VGND sky130_fd_sc_hd__buf_8
X_272_ VGND _273_/A VPWR _326_/Q VPWR _317_/Q VGND sky130_fd_sc_hd__or2_2
XFILLER_10_108 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
X_341_ repeater43/X _341_/Q VGND _343_/CLK VPWR VPWR VGND _341_/D sky130_fd_sc_hd__dfrtp_4
X_324_ repeater43/X _324_/Q VGND _297_/B VPWR VPWR VGND _324_/D sky130_fd_sc_hd__dfrtp_2
XFILLER_2_115 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_186_ VGND _342_/D _172_/A VPWR _308_/X _188_/S VPWR VGND sky130_fd_sc_hd__o21a_1
X_255_ VGND _255_/X VPWR _342_/Q VPWR _255_/B VGND _298_/C sky130_fd_sc_hd__or3_2
XFILLER_18_58 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_18_69 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_1_3 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
X_238_ VGND _320_/D VPWR _242_/A VPWR _238_/B VGND sky130_fd_sc_hd__nor2_1
X_169_ VGND _169_/Y VPWR _172_/A VPWR _169_/B VGND sky130_fd_sc_hd__nor2_1
X_307_ _308_/S VGND _307_/X VPWR _296_/Y _145_/A VPWR VGND sky130_fd_sc_hd__mux2_1
XFILLER_19_144 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_13_8 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_6_28 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_6_39 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_21_80 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
Xoutput36 VGND trimb[0] VPWR _285_/Y VPWR VGND sky130_fd_sc_hd__clkbuf_2
Xoutput14 VGND ctlp[0] VPWR _269_/A VPWR VGND sky130_fd_sc_hd__clkbuf_2
Xoutput25 VGND result[3] VPWR _318_/Q VPWR VGND sky130_fd_sc_hd__clkbuf_2
XFILLER_22_117 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XPHY_0 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XFILLER_13_139 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_3_18 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_8_110 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_340_ _346_/SET_B _340_/Q VGND _340_/CLK VPWR VPWR VGND _340_/D sky130_fd_sc_hd__dfrtp_1
X_271_ VGND _271_/Y VPWR _271_/A VPWR VGND sky130_fd_sc_hd__inv_2
X_254_ VGND _254_/Y VPWR _254_/A VPWR _254_/B VGND sky130_fd_sc_hd__nor2_1
X_323_ repeater43/X _323_/Q VGND _343_/CLK VPWR VPWR VGND _323_/D sky130_fd_sc_hd__dfrtp_1
X_185_ VGND _343_/D VPWR _185_/A VPWR VGND sky130_fd_sc_hd__inv_2
XFILLER_9_17 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_18_37 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_168_ VGND _167_/X _169_/B _165_/X VPWR _167_/X VPWR VGND _165_/X sky130_fd_sc_hd__a2bb2oi_1
X_237_ VGND _238_/B _320_/Q VPWR _329_/Q _232_/X VPWR VGND sky130_fd_sc_hd__a21oi_1
X_306_ _306_/S VGND _306_/X VPWR _294_/A _286_/B VPWR VGND sky130_fd_sc_hd__mux2_1
XFILLER_20_38 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_19_156 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_15_38 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
Xoutput37 VGND trimb[1] VPWR _288_/Y VPWR VGND sky130_fd_sc_hd__clkbuf_2
XFILLER_16_115 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
Xoutput15 VGND ctlp[1] VPWR _271_/A VPWR VGND sky130_fd_sc_hd__clkbuf_2
Xoutput26 VGND result[4] VPWR _319_/Q VPWR VGND sky130_fd_sc_hd__clkbuf_2
XFILLER_22_107 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XPHY_1 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
Xclkbuf_2_3_0_clk VGND _297_/B VPWR clkbuf_2_3_0_clk/A VPWR VGND sky130_fd_sc_hd__clkbuf_1
XFILLER_16_92 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_16_70 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XFILLER_8_155 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_270_ VGND _271_/A VPWR _325_/Q VPWR _316_/Q VGND sky130_fd_sc_hd__or2_2
X_322_ repeater43/X _322_/Q VGND _331_/CLK VPWR VPWR VGND _322_/D sky130_fd_sc_hd__dfrtp_1
XFILLER_13_82 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_253_ VGND _254_/A VPWR _347_/Q VPWR VGND sky130_fd_sc_hd__inv_2
X_184_ _188_/S VGND _185_/A VPWR _182_/X _150_/C VPWR VGND sky130_fd_sc_hd__mux2_1
X_167_ VGND _167_/X _166_/Y VPWR _160_/X _346_/Q _162_/X VPWR VGND sky130_fd_sc_hd__a22o_1
X_236_ VGND _321_/D VPWR _242_/A VPWR _236_/B VGND sky130_fd_sc_hd__nor2_1
X_305_ _306_/S VGND _305_/X VPWR _254_/B _286_/B VPWR VGND sky130_fd_sc_hd__mux2_1
XFILLER_1_52 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_1_30 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_219_ VGND _329_/D _217_/X VPWR _212_/X _329_/Q _330_/Q _216_/X VPWR VGND sky130_fd_sc_hd__a32o_1
XFILLER_19_70 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
Xoutput38 VGND trimb[2] VPWR _290_/Y VPWR VGND sky130_fd_sc_hd__clkbuf_2
Xoutput16 VGND ctlp[2] VPWR _273_/A VPWR VGND sky130_fd_sc_hd__clkbuf_2
Xoutput27 VGND result[5] VPWR _320_/Q VPWR VGND sky130_fd_sc_hd__clkbuf_2
Xclkbuf_0_clk VGND clkbuf_0_clk/X VPWR clk VPWR VGND sky130_fd_sc_hd__clkbuf_16
XPHY_2 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XFILLER_7_62 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_5_115 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_4_85 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_2_129 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
Xclkbuf_2_2_0_clk VGND _340_/CLK VPWR clkbuf_2_3_0_clk/A VPWR VGND sky130_fd_sc_hd__clkbuf_1
X_183_ VGND _188_/S _157_/A _150_/C VPWR _298_/A _324_/Q _181_/X VPWR VGND sky130_fd_sc_hd__o221ai_4
X_321_ repeater43/X _321_/Q VGND _331_/CLK VPWR VPWR VGND _321_/D sky130_fd_sc_hd__dfrtp_1
X_252_ VGND _314_/D _228_/A VPWR _297_/A _251_/X VPWR VGND sky130_fd_sc_hd__o21ai_1
X_235_ VGND _236_/B _321_/Q VPWR _330_/Q _232_/X VPWR VGND sky130_fd_sc_hd__a21oi_1
X_304_ _304_/S VGND _304_/X _216_/X VPWR _227_/A VPWR VGND sky130_fd_sc_hd__mux2_2
X_166_ VGND _166_/Y VPWR _346_/Q VPWR VGND sky130_fd_sc_hd__inv_2
XFILLER_19_82 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_218_ VGND _330_/D _217_/X VPWR _331_/Q _330_/Q _304_/X _216_/X VPWR VGND sky130_fd_sc_hd__a32o_1
X_149_ VGND _150_/C VPWR _149_/A VPWR VGND sky130_fd_sc_hd__clkbuf_2
Xoutput17 VGND ctlp[3] VPWR _275_/A VPWR VGND sky130_fd_sc_hd__clkbuf_2
Xoutput39 VGND trimb[3] VPWR _292_/Y VPWR VGND sky130_fd_sc_hd__clkbuf_2
Xoutput28 VGND result[6] VPWR _321_/Q VPWR VGND sky130_fd_sc_hd__clkbuf_2
XFILLER_16_128 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XPHY_3 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XFILLER_7_30 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_21_164 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_16_50 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XFILLER_4_53 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_251_ VGND _251_/X _172_/A _250_/X VPWR _324_/Q _181_/X VPWR VGND sky130_fd_sc_hd__o211a_1
X_320_ _346_/SET_B _320_/Q VGND _297_/B VPWR VPWR VGND _320_/D sky130_fd_sc_hd__dfrtp_1
X_182_ VGND _182_/X _196_/A _181_/X VPWR _175_/Y _286_/B VPWR VGND sky130_fd_sc_hd__o211a_1
XFILLER_13_73 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_18_29 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
Xclkbuf_2_1_0_clk VGND _331_/CLK VPWR clkbuf_2_1_0_clk/A VPWR VGND sky130_fd_sc_hd__clkbuf_1
X_303_ VGND _347_/D VPWR _303_/A VPWR VGND sky130_fd_sc_hd__inv_2
X_165_ VGND _165_/X _161_/Y VPWR _164_/Y _158_/Y _160_/X VPWR VGND sky130_fd_sc_hd__o22a_1
X_234_ VGND _322_/D VPWR _242_/A VPWR _234_/B VGND sky130_fd_sc_hd__nor2_1
XFILLER_1_87 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_19_126 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_12
X_217_ VGND _217_/X VPWR _217_/A VPWR VGND sky130_fd_sc_hd__clkbuf_2
X_148_ VGND _298_/B VPWR _341_/Q VPWR VGND sky130_fd_sc_hd__inv_2
Xoutput18 VGND ctlp[4] VPWR _277_/A VPWR VGND sky130_fd_sc_hd__clkbuf_2
Xoutput29 VGND result[7] VPWR _322_/Q VPWR VGND sky130_fd_sc_hd__clkbuf_2
XFILLER_21_73 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XPHY_4 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XFILLER_12_110 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_5_139 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_13_30 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XFILLER_1_131 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_12
X_250_ VGND _250_/X _284_/A VPWR _190_/A _260_/A _216_/A VPWR VGND sky130_fd_sc_hd__o22a_1
X_181_ VGND _181_/X VPWR _215_/A VPWR VGND sky130_fd_sc_hd__clkbuf_2
XFILLER_1_164 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_302_ VGND _303_/A _254_/A VPWR _157_/A _147_/A _300_/Y _301_/X VPWR VGND sky130_fd_sc_hd__o32a_1
X_233_ VGND _234_/B _322_/Q VPWR _331_/Q _232_/X VPWR VGND sky130_fd_sc_hd__a21oi_1
X_164_ VGND _164_/Y VPWR _164_/A VPWR VGND sky130_fd_sc_hd__inv_2
XFILLER_19_138 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_10_53 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_18_3 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
X_216_ VGND _216_/X VPWR _216_/A VPWR VGND sky130_fd_sc_hd__clkbuf_2
X_147_ VGND _147_/Y VPWR _147_/A VPWR VGND sky130_fd_sc_hd__inv_2
Xoutput19 VGND ctlp[5] VPWR _279_/A VPWR VGND sky130_fd_sc_hd__clkbuf_2
XFILLER_21_30 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XFILLER_7_87 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
Xclkbuf_2_0_0_clk VGND _343_/CLK VPWR clkbuf_2_1_0_clk/A VPWR VGND sky130_fd_sc_hd__clkbuf_1
XPHY_5 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XFILLER_7_43 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_21_144 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_12
XFILLER_16_85 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_8_115 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_5_107 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_4_77 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_180_ VGND _215_/A VPWR _298_/C VPWR _298_/A VGND _298_/B sky130_fd_sc_hd__or3_1
XFILLER_1_9 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_301_ VGND _301_/X _299_/X _162_/X VPWR _254_/A _160_/X _347_/Q VPWR VGND sky130_fd_sc_hd__o221a_1
X_163_ VGND _164_/A _345_/Q VPWR _162_/X _158_/Y _160_/A VPWR VGND sky130_fd_sc_hd__o22a_1
X_232_ VGND _232_/X VPWR _232_/A VPWR VGND sky130_fd_sc_hd__clkbuf_2
XFILLER_19_30 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_18_150 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
X_215_ VGND _216_/A VPWR _215_/A VPWR VGND sky130_fd_sc_hd__inv_2
X_146_ VGND _147_/A VPWR _177_/A VPWR _341_/Q VGND _146_/C sky130_fd_sc_hd__and3_2
XFILLER_15_164 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_21_42 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XPHY_6 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XFILLER_7_11 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_21_156 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_12_101 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_13_87 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_13_65 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_1_144 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
X_300_ VGND _300_/Y _299_/X _162_/X VPWR _347_/Q _160_/X _254_/A VPWR VGND sky130_fd_sc_hd__a221oi_2
X_162_ VGND _162_/X VPWR _162_/A VPWR VGND sky130_fd_sc_hd__clkbuf_2
X_231_ VGND _232_/A _146_/C _255_/B _150_/C VPWR _298_/A _162_/X VPWR VGND sky130_fd_sc_hd__o2111a_1
XFILLER_1_79 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
Xinput1 VGND input1/X VPWR cal VPWR VGND sky130_fd_sc_hd__clkbuf_1
XFILLER_10_44 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_145_ VGND _146_/C VPWR _145_/A VPWR _304_/S VGND sky130_fd_sc_hd__nand2_1
X_214_ VGND _331_/D _331_/Q VPWR _217_/A _212_/X _181_/X VPWR VGND sky130_fd_sc_hd__a22o_1
XFILLER_21_87 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XPHY_7 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XFILLER_7_78 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_21_124 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_12
XFILLER_7_23 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XFILLER_8_128 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XFILLER_4_164 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_4_46 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_161_ VGND _161_/Y VPWR _344_/Q VPWR VGND sky130_fd_sc_hd__inv_2
X_230_ VGND _242_/A VPWR _248_/A VPWR VGND sky130_fd_sc_hd__clkbuf_2
XFILLER_1_25 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
Xinput2 VGND _162_/A VPWR comp VPWR VGND sky130_fd_sc_hd__buf_1
XFILLER_10_67 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_19_87 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_213_ VGND _217_/A VPWR _304_/X VPWR VGND sky130_fd_sc_hd__inv_2
X_144_ VGND _304_/S VPWR _144_/A VPWR VGND sky130_fd_sc_hd__buf_1
XFILLER_21_99 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_15_133 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_15_144 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_15_155 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_16_3 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XPHY_8 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XFILLER_21_136 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XFILLER_16_99 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_12_158 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_16_11 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_4_110 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_4_154 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XFILLER_4_58 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_4_36 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XFILLER_4_69 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_1_124 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_1_157 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_160_ VGND _160_/X VPWR _160_/A VPWR VGND sky130_fd_sc_hd__clkbuf_2
X_289_ VGND _290_/A VPWR _338_/Q VPWR _311_/Q VGND sky130_fd_sc_hd__or2_2
Xinput3 VGND _227_/A VPWR en VPWR VGND sky130_fd_sc_hd__clkbuf_2
X_143_ VGND _144_/A VPWR _177_/A VPWR _341_/Q VGND _149_/A sky130_fd_sc_hd__and3_1
XFILLER_19_99 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
X_212_ VGND _212_/X VPWR _304_/X VPWR VGND sky130_fd_sc_hd__buf_1
XFILLER_19_22 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XFILLER_19_11 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_18_164 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_18_131 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XPHY_9 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XFILLER_12_115 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_7_130 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_7_163 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_13_46 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_6_3 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_1_38 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
X_288_ VGND _288_/Y VPWR _288_/A VPWR VGND sky130_fd_sc_hd__inv_2
Xinput4 VGND input4/X VPWR rstn VPWR VGND sky130_fd_sc_hd__buf_1
X_211_ VGND _332_/D _153_/B VPWR _197_/X _332_/Q _206_/A VPWR VGND sky130_fd_sc_hd__a22o_1
X_142_ VGND _149_/A VPWR _343_/Q VPWR VGND sky130_fd_sc_hd__inv_2
XFILLER_10_58 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XFILLER_15_102 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_16_35 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_13_25 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_14_90 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
X_287_ VGND _288_/A VPWR _337_/Q VPWR _310_/Q VGND sky130_fd_sc_hd__or2_2
XFILLER_19_46 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_141_ VGND _145_/A VPWR _227_/A VPWR VGND sky130_fd_sc_hd__inv_2
X_210_ VGND _333_/D _306_/S VPWR _209_/X _153_/A _207_/C VPWR VGND sky130_fd_sc_hd__o22ai_1
X_339_ _346_/SET_B _339_/Q VGND _340_/CLK VPWR VPWR VGND _339_/D sky130_fd_sc_hd__dfrtp_1
XFILLER_21_25 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_12_128 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_16_58 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_14_3 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XFILLER_5_60 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_286_ VGND _286_/Y VPWR _306_/S VPWR _286_/B VGND sky130_fd_sc_hd__nand2_1
X_140_ VGND _177_/A VPWR _342_/Q VPWR VGND sky130_fd_sc_hd__inv_2
X_338_ _346_/SET_B _338_/Q VGND _340_/CLK VPWR VPWR VGND _338_/D sky130_fd_sc_hd__dfrtp_1
X_269_ VGND _269_/Y VPWR _269_/A VPWR VGND sky130_fd_sc_hd__inv_2
XFILLER_7_155 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_7_144 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XFILLER_8_82 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XFILLER_8_71 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_4_29 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_1_117 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_285_ VGND _285_/Y VPWR _285_/A VPWR VGND sky130_fd_sc_hd__inv_2
XFILLER_4_3 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XFILLER_2_84 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
Xclkbuf_1_1_0_clk VGND clkbuf_2_3_0_clk/A VPWR clkbuf_0_clk/X VPWR VGND sky130_fd_sc_hd__clkbuf_1
XFILLER_18_124 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_268_ VGND _269_/A VPWR _324_/Q VPWR _315_/Q VGND sky130_fd_sc_hd__or2_2
X_337_ _346_/SET_B _337_/Q VGND _340_/CLK VPWR VPWR VGND _337_/D sky130_fd_sc_hd__dfrtp_1
X_199_ VGND _338_/D _338_/Q VPWR _339_/Q _194_/X _197_/X _193_/Y VPWR VGND sky130_fd_sc_hd__a32o_1
XFILLER_2_73 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_21_49 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_11_163 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_7_123 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_4_115 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_17_81 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_13_39 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_13_17 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_5_95 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_5_40 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_284_ VGND _285_/A VPWR _284_/A VPWR _309_/Q VGND sky130_fd_sc_hd__or2_2
XFILLER_19_38 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_10_29 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XFILLER_18_158 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
X_336_ _346_/SET_B _336_/Q VGND _340_/CLK VPWR VPWR VGND _336_/D sky130_fd_sc_hd__dfrtp_1
X_267_ VGND _309_/D VPWR _267_/A VPWR _267_/B VGND sky130_fd_sc_hd__nor2_1
X_198_ VGND _339_/D _339_/Q VPWR _340_/Q _194_/X _197_/X _193_/Y VPWR VGND sky130_fd_sc_hd__a32o_1
X_319_ _346_/SET_B _319_/Q VGND _297_/B VPWR VPWR VGND _319_/D sky130_fd_sc_hd__dfrtp_1
XFILLER_11_131 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
Xclkbuf_1_0_0_clk VGND clkbuf_2_1_0_clk/A VPWR clkbuf_0_clk/X VPWR VGND sky130_fd_sc_hd__clkbuf_1
XFILLER_8_51 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XFILLER_4_127 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XFILLER_0_141 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_5_30 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_14_83 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_283_ VGND _283_/Y VPWR _283_/A VPWR VGND sky130_fd_sc_hd__inv_2
XFILLER_18_104 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_18_115 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_266_ VGND _267_/B _309_/Q VPWR _284_/A _258_/S VPWR VGND sky130_fd_sc_hd__a21oi_1
X_197_ VGND _197_/X VPWR _260_/A VPWR VGND sky130_fd_sc_hd__clkbuf_2
X_335_ repeater43/X _335_/Q VGND _343_/CLK VPWR VPWR VGND _335_/D sky130_fd_sc_hd__dfrtp_1
XFILLER_2_53 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_249_ VGND _297_/A VPWR _314_/Q VPWR VGND sky130_fd_sc_hd__inv_2
X_318_ repeater43/X _318_/Q VGND _331_/CLK VPWR VPWR VGND _318_/D sky130_fd_sc_hd__dfrtp_1
XFILLER_20_165 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XFILLER_20_110 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_7_114 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_0_164 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_282_ VGND _283_/A VPWR _331_/Q VPWR _322_/Q VGND sky130_fd_sc_hd__or2_2
XFILLER_18_138 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_12
X_334_ repeater43/X _334_/Q VGND _343_/CLK VPWR VPWR VGND _334_/D sky130_fd_sc_hd__dfrtp_1
X_265_ VGND _310_/D VPWR _267_/A VPWR _265_/B VGND sky130_fd_sc_hd__nor2_1
X_196_ VGND _260_/A VPWR _196_/A VPWR VGND sky130_fd_sc_hd__inv_2
XFILLER_11_30 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_11_96 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
X_248_ VGND _315_/D VPWR _248_/A VPWR _248_/B VGND sky130_fd_sc_hd__nor2_1
X_317_ repeater43/X _317_/Q VGND _331_/CLK VPWR VPWR VGND _317_/D sky130_fd_sc_hd__dfrtp_1
X_179_ VGND _286_/B VPWR _191_/B VPWR VGND sky130_fd_sc_hd__clkbuf_2
XFILLER_20_122 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_12
XFILLER_11_144 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_11_155 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_8_97 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_5_87 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_281_ VGND _281_/Y VPWR _281_/A VPWR VGND sky130_fd_sc_hd__inv_2
XPHY_40 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
X_195_ VGND _340_/D _340_/Q VPWR _194_/X _306_/S _193_/Y VPWR VGND sky130_fd_sc_hd__a22o_1
X_264_ VGND _265_/B _310_/Q VPWR _337_/Q _258_/S VPWR VGND sky130_fd_sc_hd__a21oi_1
X_333_ repeater43/X _333_/Q VGND _343_/CLK VPWR VPWR VGND _333_/D sky130_fd_sc_hd__dfrtp_4
XFILLER_11_64 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_247_ VGND _248_/B _315_/Q VPWR _324_/Q _232_/A VPWR VGND sky130_fd_sc_hd__a21oi_1
X_316_ repeater43/X _316_/Q VGND _331_/CLK VPWR VPWR VGND _316_/D sky130_fd_sc_hd__dfrtp_1
XFILLER_20_134 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_12
X_178_ VGND _191_/B VPWR _298_/C VPWR _298_/A VGND _341_/Q sky130_fd_sc_hd__or3_4
XFILLER_22_30 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_17_96 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XFILLER_17_30 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_10_3 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XFILLER_5_11 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_280_ VGND _281_/A VPWR _330_/Q VPWR _321_/Q VGND sky130_fd_sc_hd__or2_1
XFILLER_14_53 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XPHY_41 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XPHY_30 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
X_194_ VGND _194_/X VPWR _194_/A VPWR VGND sky130_fd_sc_hd__buf_1
X_263_ VGND _311_/D VPWR _267_/A VPWR _263_/B VGND sky130_fd_sc_hd__nor2_1
X_332_ repeater43/X _332_/Q VGND _340_/CLK VPWR VPWR VGND _332_/D sky130_fd_sc_hd__dfrtp_4
XFILLER_11_76 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_11_87 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_20_146 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_20_157 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
X_246_ VGND _316_/D VPWR _248_/A VPWR _246_/B VGND sky130_fd_sc_hd__nor2_1
X_315_ repeater43/X _315_/Q VGND _343_/CLK VPWR VPWR VGND _315_/D sky130_fd_sc_hd__dfrtp_1
X_177_ VGND _298_/A VPWR _177_/A VPWR VGND sky130_fd_sc_hd__clkbuf_2
XFILLER_7_139 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_229_ VGND _226_/X _323_/D input1/X VPWR _248_/A VPWR VGND _175_/Y sky130_fd_sc_hd__a2bb2o_1
XFILLER_3_153 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_3_164 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_0_112 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_0_156 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_5_78 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XPHY_31 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
X_331_ repeater43/X _331_/Q VGND _331_/CLK VPWR VPWR VGND _331_/D sky130_fd_sc_hd__dfrtp_1
XPHY_42 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
X_262_ VGND _263_/B _311_/Q VPWR _338_/Q _258_/S VPWR VGND sky130_fd_sc_hd__a21oi_1
X_193_ VGND _193_/Y VPWR _194_/A VPWR VGND sky130_fd_sc_hd__inv_2
XPHY_20 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XFILLER_2_13 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_11_11 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_2_6 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_314_ _346_/SET_B _314_/Q VGND _297_/B VPWR VPWR VGND _314_/D sky130_fd_sc_hd__dfrtp_1
XFILLER_14_122 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_14_133 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_245_ VGND _246_/B _316_/Q VPWR _325_/Q _232_/A VPWR VGND sky130_fd_sc_hd__a21oi_1
X_176_ VGND _298_/C VPWR _343_/Q VPWR VGND sky130_fd_sc_hd__buf_1
XFILLER_22_54 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_22_21 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_0_3 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
X_228_ VGND _248_/A VPWR _228_/A VPWR VGND sky130_fd_sc_hd__inv_2
X_159_ VGND _160_/A VPWR _162_/A VPWR VGND sky130_fd_sc_hd__inv_2
XFILLER_17_87 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_17_65 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_0_146 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XFILLER_5_68 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XPHY_43 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
X_330_ repeater43/X _330_/Q VGND _331_/CLK VPWR VPWR VGND _330_/D sky130_fd_sc_hd__dfrtp_1
XPHY_32 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
X_261_ VGND _312_/D VPWR _261_/A VPWR _267_/A VGND sky130_fd_sc_hd__nor2_1
XPHY_21 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
X_192_ VGND _194_/A VPWR _305_/X VPWR _192_/B VGND sky130_fd_sc_hd__or2_1
XPHY_10 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XFILLER_17_120 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_17_164 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_2_58 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_313_ _346_/SET_B _313_/Q VGND _340_/CLK VPWR VPWR VGND _313_/D sky130_fd_sc_hd__dfrtp_1
X_244_ VGND _317_/D VPWR _248_/A VPWR _244_/B VGND sky130_fd_sc_hd__nor2_1
X_175_ VGND _175_/Y VPWR _323_/Q VPWR VGND sky130_fd_sc_hd__inv_2
XFILLER_20_115 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_11_115 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_22_88 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XFILLER_22_99 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_22_66 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
X_227_ VGND _228_/A VPWR _227_/A VPWR _304_/S VGND sky130_fd_sc_hd__nand2_1
X_158_ VGND _158_/Y VPWR _345_/Q VPWR VGND sky130_fd_sc_hd__inv_2
XFILLER_3_144 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_0_125 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_12
XFILLER_5_47 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_5_25 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XPHY_22 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XPHY_33 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XPHY_44 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
X_260_ VGND _267_/A VPWR _260_/A VPWR _260_/B VGND sky130_fd_sc_hd__nor2_2
XPHY_11 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
X_191_ VGND _192_/B VPWR _323_/Q VPWR _191_/B VGND sky130_fd_sc_hd__nor2_1
XFILLER_2_37 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
X_243_ VGND _244_/B _317_/Q VPWR _326_/Q _232_/A VPWR VGND sky130_fd_sc_hd__a21oi_1
X_312_ _346_/SET_B _312_/Q VGND _340_/CLK VPWR VPWR VGND _312_/D sky130_fd_sc_hd__dfrtp_1
X_174_ VGND _344_/D _161_/Y VPWR _147_/A _344_/Q _172_/A VPWR VGND sky130_fd_sc_hd__a22o_1
XFILLER_22_78 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_19_3 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_157_ VGND _172_/A VPWR _157_/A VPWR VGND sky130_fd_sc_hd__clkbuf_2
XFILLER_6_131 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_6_164 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_226_ VGND _226_/X _147_/A VPWR _150_/C _225_/X VPWR VGND sky130_fd_sc_hd__o21a_1
XFILLER_8_58 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_209_ VGND _209_/X _153_/A VPWR _153_/B _333_/Q _332_/Q VPWR VGND sky130_fd_sc_hd__a22o_1
XFILLER_14_35 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XPHY_12 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XPHY_23 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XFILLER_17_144 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XPHY_45 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XPHY_34 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
X_190_ VGND _306_/S VPWR _190_/A VPWR VGND sky130_fd_sc_hd__clkbuf_2
XFILLER_11_25 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_14_158 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
X_173_ VGND _172_/Y _345_/D _345_/Q VPWR _147_/Y VPWR VGND _147_/Y sky130_fd_sc_hd__a2bb2o_1
X_242_ VGND _318_/D VPWR _242_/A VPWR _242_/B VGND sky130_fd_sc_hd__nor2_1
X_311_ _346_/SET_B _311_/Q VGND _340_/CLK VPWR VPWR VGND _311_/D sky130_fd_sc_hd__dfrtp_1
XFILLER_9_151 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_11_139 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_22_46 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_22_13 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_3_81 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_156_ VGND _157_/A VPWR _196_/A VPWR _225_/B VGND sky130_fd_sc_hd__or2_2
X_225_ VGND _225_/X VPWR _336_/Q VPWR _225_/B VGND sky130_fd_sc_hd__and2_1
X_208_ VGND _334_/D _334_/Q VPWR _207_/X _206_/A _204_/Y VPWR VGND sky130_fd_sc_hd__o22a_1
XFILLER_0_105 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_14_58 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_6_70 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XPHY_35 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XPHY_24 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XPHY_13 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XFILLER_9_3 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XFILLER_17_156 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_14_115 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_310_ _346_/SET_B _310_/Q VGND _340_/CLK VPWR VPWR VGND _310_/D sky130_fd_sc_hd__dfrtp_1
X_172_ VGND _172_/Y VPWR _172_/A VPWR _172_/B VGND sky130_fd_sc_hd__nor2_1
X_241_ VGND _242_/B _318_/Q VPWR _327_/Q _232_/X VPWR VGND sky130_fd_sc_hd__a21oi_1
X_224_ VGND _324_/D _217_/A VPWR _304_/X _324_/Q _325_/Q _216_/A VPWR VGND sky130_fd_sc_hd__a32o_1
XFILLER_6_122 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
X_155_ VGND _225_/B VPWR _254_/B VPWR VGND sky130_fd_sc_hd__inv_2
XFILLER_6_155 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_8_38 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_17_14 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XFILLER_17_25 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_207_ VGND _207_/X VPWR _333_/Q VPWR _332_/Q VGND _207_/C sky130_fd_sc_hd__and3_1
XFILLER_0_83 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_0_117 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_14_26 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XPHY_25 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XPHY_36 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XPHY_14 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XFILLER_17_113 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_171_ VGND _172_/B _344_/Q VPWR _164_/A _161_/Y _164_/Y VPWR VGND sky130_fd_sc_hd__o22a_1
X_240_ VGND _319_/D VPWR _242_/A VPWR _240_/B VGND sky130_fd_sc_hd__nor2_1
XFILLER_9_164 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_9_131 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_22_59 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_8_28 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_223_ VGND _325_/D _217_/A VPWR _304_/X _325_/Q _326_/Q _216_/A VPWR VGND sky130_fd_sc_hd__a32o_1
X_154_ VGND _254_/B VPWR _154_/A VPWR VGND sky130_fd_sc_hd__buf_1
X_206_ VGND _207_/C VPWR _206_/A VPWR VGND sky130_fd_sc_hd__inv_2
XFILLER_5_18 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XPHY_37 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XPHY_26 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XPHY_15 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XFILLER_11_39 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_170_ VGND _169_/Y _346_/D _346_/Q VPWR _147_/Y VPWR VGND _147_/Y sky130_fd_sc_hd__a2bb2o_1
X_299_ VGND _299_/X _165_/X VPWR _167_/X _166_/Y _160_/X VPWR VGND sky130_fd_sc_hd__o22a_1
XFILLER_3_73 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_22_38 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_222_ VGND _326_/D _217_/X VPWR _212_/X _326_/Q _327_/Q _216_/A VPWR VGND sky130_fd_sc_hd__a32o_1
XFILLER_10_164 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_153_ VGND _154_/A _334_/Q VPWR _153_/A VPWR _153_/B VGND _335_/Q sky130_fd_sc_hd__or4b_4
XFILLER_17_38 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
X_205_ VGND _335_/D _335_/Q VPWR _206_/A _204_/Y VPWR VGND sky130_fd_sc_hd__o21a_1
XFILLER_9_94 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_0_30 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_6_84 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XPHY_27 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XPHY_38 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XPHY_16 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XFILLER_6_51 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XFILLER_15_82 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_11_18 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_7_3 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_9_144 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_3_30 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
X_298_ VGND _298_/X VPWR _298_/A VPWR _298_/B VGND _298_/C sky130_fd_sc_hd__and3_1
X_221_ VGND _327_/D _217_/X VPWR _212_/X _327_/Q _328_/Q _216_/X VPWR VGND sky130_fd_sc_hd__a32o_1
X_152_ VGND _153_/B VPWR _332_/Q VPWR VGND sky130_fd_sc_hd__inv_2
XFILLER_3_117 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_3_139 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_204_ VGND _204_/Y _190_/A VPWR _333_/Q _332_/Q _334_/Q VPWR VGND sky130_fd_sc_hd__a31oi_2
XFILLER_0_75 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_18_93 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XFILLER_22_3 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XPHY_28 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XPHY_17 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XFILLER_17_127 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XPHY_39 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XFILLER_22_141 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_14_108 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
X_297_ VGND _297_/Y VPWR _297_/A VPWR _297_/B VGND sky130_fd_sc_hd__nor2_2
XFILLER_13_163 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_220_ VGND _328_/D _217_/X VPWR _212_/X _328_/Q _329_/Q _216_/X VPWR VGND sky130_fd_sc_hd__a32o_1
XFILLER_6_115 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_10_100 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_10_144 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XFILLER_10_133 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_151_ VGND _153_/A VPWR _333_/Q VPWR VGND sky130_fd_sc_hd__inv_2
XFILLER_3_129 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XFILLER_0_54 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_9_30 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_203_ VGND _206_/A _147_/Y VPWR _336_/Q _225_/B _298_/C VPWR VGND sky130_fd_sc_hd__a31o_1
XFILLER_9_41 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_15_3 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_6_97 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_17_106 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XPHY_29 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XPHY_18 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XFILLER_17_139 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_15_95 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_15_51 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_16_161 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XFILLER_22_164 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_296_ VGND _296_/Y _286_/B _284_/A VPWR _306_/S _342_/Q _255_/B VPWR VGND sky130_fd_sc_hd__o221ai_1
XFILLER_3_87 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
X_150_ VGND _196_/A VPWR _342_/Q VPWR _298_/B VGND _150_/C sky130_fd_sc_hd__or3_4
X_279_ VGND _279_/Y VPWR _279_/A VPWR VGND sky130_fd_sc_hd__inv_2
XFILLER_17_7 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_202_ VGND _336_/D _284_/A VPWR _337_/Q _194_/X _197_/X _193_/Y VPWR VGND sky130_fd_sc_hd__a32o_1
XFILLER_0_88 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_8
XPHY_19 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_3
XFILLER_9_9 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
Xoutput40 VGND trimb[4] VPWR _294_/Y VPWR VGND sky130_fd_sc_hd__clkbuf_2
XFILLER_15_30 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
Xoutput5 VGND clkc VPWR _297_/Y VPWR VGND sky130_fd_sc_hd__buf_1
XFILLER_3_11 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_295_ VGND _308_/S _181_/X _190_/A _286_/B VPWR _342_/Q _255_/B VPWR VGND sky130_fd_sc_hd__o2111a_1
XFILLER_10_157 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_278_ VGND _279_/A VPWR _329_/Q VPWR _320_/Q VGND sky130_fd_sc_hd__or2_1
X_347_ _346_/SET_B _347_/Q VGND _297_/B VPWR VPWR VGND _347_/D sky130_fd_sc_hd__dfrtp_1
XFILLER_5_3 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_2_153 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_6
XFILLER_2_164 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
X_201_ VGND _284_/A VPWR _336_/Q VPWR VGND sky130_fd_sc_hd__clkbuf_2
XFILLER_9_87 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_9_54 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_20_86 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_20_53 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_20_3 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
XFILLER_15_75 VGND VPWR VPWR VGND sky130_fd_sc_hd__decap_4
Xoutput6 VGND ctln[0] VPWR _269_/Y VPWR VGND sky130_fd_sc_hd__clkbuf_2
Xoutput30 VGND sample VPWR _286_/Y VPWR VGND sky130_fd_sc_hd__clkbuf_2
Xoutput41 VGND valid VPWR _298_/X VPWR VGND sky130_fd_sc_hd__clkbuf_2
.ends

.subckt SAR dvss avss avdd dvdd vinn vinp
Xlatch_0 dvss comp latch_0/R latch_0/S avdd avss latch
XDAC_0 dvss ctlp7 avdd avdd DAC_0/out sample avss ctlp0 ctlp1 ctlp2 ctlp3 vinp ctlp4
+ ctlp5 decap_3$1_0/w_0_269# ctlp6 DAC
XDAC_1 dvss ctln7 avdd avss DAC_1/out sample avss ctln0 ctln1 ctln2 ctln3 vinn ctln4
+ ctln5 decap_3$1_0/w_0_269# ctln6 DAC
Xdecap_3$1_0 dvss decap_3$1_0/w_0_269# avdd avss decap_3$1
Xcomparator_0 dvss clkc avss DAC_1/out DAC_0/out trim0 trim1 trim2 trim3 trim4 avdd
+ trimb0 latch_0/R trimb1 trimb2 latch_0/S trimb3 trimb4 comparator
Xsarlogic_0 ctln0 ctln1 ctln2 ctln3 ctln4 ctln5 ctln6 ctln7 ctlp0 ctlp1 ctlp2 ctlp3
+ ctlp4 ctlp5 ctlp6 ctlp7 cal clk clkc comp en result0 result1 result2 result3 result4
+ result5 result6 result7 rstn sample trim0 trim1 trim2 trim3 trim4 trimb0 trimb1
+ trimb2 trimb3 trimb4 valid dvdd dvss sarlogic
.ends

.subckt user_analog_project_wrapper wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0] wbs_adr_i[10]
+ wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15] wbs_adr_i[16]
+ wbs_adr_i[17] wbs_adr_i[1] wbs_adr_i[2] wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6]
+ wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9] wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11]
+ wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14] wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[1]
+ wbs_dat_i[2] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[1] wbs_dat_o[2] wbs_dat_o[3]
+ wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6] wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0]
+ wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3] wbs_stb_i wbs_we_i wbs_dat_i[17] wbs_dat_i[18]
+ wbs_dat_i[19] wbs_adr_i[18] wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23]
+ wbs_dat_i[24] wbs_dat_i[25] wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29]
+ wbs_adr_i[19] wbs_dat_i[30] wbs_dat_i[31] la_oenb[0] wbs_adr_i[20] wbs_adr_i[21]
+ wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26] wbs_adr_i[27]
+ wbs_adr_i[28] wbs_adr_i[29] la_oenb[1] wbs_adr_i[30] wbs_adr_i[31] la_oenb[2] wbs_dat_o[17]
+ wbs_dat_o[18] wbs_dat_o[19] la_oenb[3] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22]
+ wbs_dat_o[23] wbs_dat_o[24] wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28]
+ wbs_dat_o[29] la_oenb[4] wbs_dat_o[30] wbs_dat_o[31] la_oenb[5] la_data_in[0] la_data_in[1]
+ la_data_in[2] la_data_in[3] la_data_in[4] la_data_in[5] la_data_out[0] la_data_out[1]
+ la_data_out[2] la_data_out[3] la_data_out[4] la_data_out[5] la_data_in[23] la_data_in[24]
+ la_data_in[25] la_oenb[6] la_oenb[7] la_oenb[8] la_oenb[9] la_data_in[26] la_data_in[11]
+ la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[6] la_data_in[7] la_data_in[8]
+ la_data_in[9] la_data_in[15] la_data_out[10] la_data_out[11] la_data_out[12] la_data_out[13]
+ la_data_out[14] la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18]
+ la_data_out[19] la_data_in[16] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23]
+ la_data_out[24] la_data_out[25] la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[10]
+ la_data_out[6] la_data_out[7] la_data_out[8] la_data_out[9] la_data_in[20] la_oenb[10]
+ la_oenb[11] la_oenb[12] la_oenb[13] la_oenb[14] la_oenb[15] la_oenb[16] la_oenb[17]
+ la_oenb[18] la_oenb[19] la_data_in[21] la_oenb[20] la_oenb[21] la_oenb[22] la_oenb[23]
+ la_oenb[24] la_oenb[25] la_data_in[22] la_data_in[39] la_oenb[45] la_data_in[40]
+ la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29] la_data_in[41] la_data_out[30]
+ la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34] la_data_out[35]
+ la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39] la_data_in[42] la_data_out[40]
+ la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44] la_data_out[45]
+ la_data_out[46] la_data_in[43] la_data_in[44] la_data_in[45] la_data_in[46] la_oenb[46]
+ la_oenb[38] la_oenb[39] la_oenb[37] la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43]
+ la_data_in[27] la_data_in[28] la_data_in[29] la_oenb[44] la_data_in[30] la_data_in[31]
+ la_data_in[32] la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37]
+ la_oenb[26] la_oenb[27] la_oenb[28] la_oenb[29] la_data_in[38] la_oenb[30] la_oenb[31]
+ la_oenb[32] la_oenb[33] la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[47] la_oenb[48]
+ la_oenb[49] la_oenb[50] la_oenb[51] la_oenb[52] la_oenb[53] la_oenb[54] la_oenb[55]
+ la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59] la_oenb[60] la_oenb[61] la_oenb[62]
+ la_oenb[63] la_oenb[64] la_oenb[65] la_oenb[66] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54] la_data_in[55]
+ la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[60] la_data_in[61]
+ la_data_in[62] la_data_in[63] la_data_out[47] la_data_out[48] la_data_out[49] la_data_in[64]
+ la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_in[65] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_in[66] la_data_in[67] la_data_in[72]
+ la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76] la_data_in[77] la_data_in[78]
+ la_data_in[79] la_data_in[80] la_data_in[81] la_data_in[82] la_data_in[83] la_data_in[84]
+ la_data_in[85] la_data_in[86] la_data_in[87] la_data_in[69] la_oenb[67] la_oenb[68]
+ la_oenb[69] la_oenb[70] la_oenb[71] la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75]
+ la_oenb[76] la_oenb[77] la_oenb[78] la_oenb[79] la_oenb[80] la_oenb[81] la_oenb[82]
+ la_oenb[83] la_oenb[84] la_oenb[85] la_oenb[86] la_oenb[87] la_data_out[68] la_data_out[69]
+ la_data_in[70] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_in[71] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_in[68] la_oenb[88] la_oenb[89]
+ la_oenb[90] la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96]
+ la_oenb[97] la_oenb[98] la_oenb[99] la_data_in[101] la_data_in[102] la_data_in[103]
+ la_data_in[104] la_data_in[105] la_data_in[106] la_data_in[107] la_data_in[108]
+ la_data_in[100] la_data_in[90] la_data_in[91] la_data_in[92] la_data_in[93] la_data_in[94]
+ la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98] la_data_in[99] la_data_out[100]
+ la_data_out[101] la_data_out[102] la_data_out[103] la_data_out[104] la_data_out[105]
+ la_data_out[93] la_data_out[106] la_data_out[94] la_data_out[107] la_data_out[95]
+ la_data_out[96] la_data_out[108] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[92] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_data_in[88] la_data_in[89] la_data_out[88]
+ la_data_out[89] la_data_out[90] la_data_out[91] la_data_in[119] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_in[116] la_data_in[117] la_data_out[123]
+ la_data_in[112] la_data_out[124] la_data_out[125] la_data_out[126] la_data_out[127]
+ la_data_in[118] la_oenb[109] la_data_in[120] la_oenb[110] la_data_in[121] la_oenb[111]
+ la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117] la_oenb[118]
+ la_oenb[119] la_data_in[122] la_data_in[123] la_oenb[120] la_oenb[121] la_oenb[122]
+ la_oenb[123] la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_data_in[124]
+ la_data_in[125] la_data_in[126] la_data_in[127] la_data_out[110] user_clock2 user_irq[0]
+ la_data_in[113] user_irq[1] la_data_in[114] user_irq[2] la_data_out[111] la_data_out[112]
+ la_data_out[109] la_data_in[109] la_data_out[113] la_data_in[110] la_data_out[114]
+ la_oenb[108] la_data_out[115] la_data_out[116] la_data_in[111] la_data_out[117]
+ la_data_in[115] la_data_out[118] la_data_out[119] gpio_analog[2] gpio_analog[3]
+ gpio_analog[4] gpio_analog[5] gpio_analog[6] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4]
+ gpio_noesd[5] gpio_noesd[6] io_analog[0] io_analog[1] io_analog[2] io_analog[3]
+ io_analog[4] io_clamp_high[0] io_clamp_low[0] io_in[10] io_in[11] io_in[12] io_in[13]
+ io_in[9] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12] io_in_3v3[13] io_in_3v3[9] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[9] io_out[10] io_out[11] io_out[12] io_out[13]
+ io_out[9] vccd1 vdda1 vssa1 io_in[16] io_in[17] gpio_analog[9] gpio_noesd[10] io_analog[5]
+ io_analog[6] io_analog[7] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17]
+ io_analog[8] io_analog[9] gpio_noesd[7] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17]
+ gpio_noesd[8] io_clamp_high[1] io_clamp_high[2] gpio_noesd[9] io_clamp_low[1] io_out[14]
+ io_out[15] io_out[16] io_out[17] io_clamp_low[2] gpio_analog[10] io_analog[10] vccd2
+ gpio_analog[7] gpio_analog[8] io_in[14] io_in[15] vssa2 io_in_3v3[24] io_in_3v3[25]
+ io_in_3v3[26] gpio_analog[16] gpio_analog[17] gpio_analog[11] gpio_analog[12] gpio_noesd[11]
+ io_in[18] io_in[19] io_in[20] io_in[21] io_oeb[18] io_oeb[19] io_oeb[20] io_oeb[21]
+ io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25] io_oeb[26] io_in[22] io_in[23] io_in[24]
+ io_in[25] io_in[26] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15]
+ io_out[18] io_out[19] io_out[20] io_out[21] io_out[22] io_out[23] io_out[24] io_out[25]
+ io_out[26] gpio_noesd[16] gpio_noesd[17] gpio_analog[13] gpio_analog[14] gpio_analog[15]
+ io_in_3v3[18] io_in_3v3[19] vdda2 io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ vssd2 io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in[1] io_oeb[0] gpio_noesd[0] io_in[2]
+ io_in[3] io_in[4] io_in[5] io_out[1] io_in[6] io_in_3v3[1] io_in[7] io_in[8] gpio_analog[0]
+ io_oeb[1] io_in_3v3[0] io_out[2] io_out[3] io_out[4] io_out[5] io_out[6] io_out[7]
+ io_out[8] gpio_analog[1] gpio_noesd[1] io_in[0] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8] vssd1 io_in_3v3[5]
+ io_out[0]
XSAR_0 vssd2 vssa1 vdda1 vccd2 io_analog[4] io_analog[4] SAR
.ends
